R1 N1 N41 5000.00005
R2 N2 N42 5000.00005
R3 N3 N43 5000.00005
R4 N4 N44 5000.00005
R5 N5 N45 5000.00005
R6 N6 N46 5000.00005
R7 N7 N47 5000.00005
R8 N8 N48 5000.00005
R9 N9 N49 5000.00005
R10 N10 N50 5000.00005
R11 N11 N51 5000.00005
R12 N12 N52 5000.00005
R13 N13 N53 5000.00005
R14 N14 N54 5000.00005
R15 N15 N55 5000.00005
R16 N16 N56 5000.00005
R17 N17 N57 5000.00005
R18 N18 N58 5000.00005
R19 N19 N59 5000.00005
R20 N20 N60 5000.00005
R21 N21 N61 5000.00005
R22 N22 N62 5000.00005
R23 N23 N63 5.00005
R24 N24 N64 5000.00005
R25 N25 N65 5000.00005
R26 N26 N66 5000.00005
R27 N27 N67 5000.00005
R28 N28 N68 5000.00005
R29 N29 N69 5000.00005
R30 N30 N70 5000.00005
R31 N31 N71 5000.00005
R32 N32 N72 5000.00005
R33 N33 N73 5000.00005
R34 N34 N74 5000.00005
R35 N35 N75 5000.00005
R36 N36 N76 5000.00005
R37 N37 N77 5000.00005
R38 N38 N78 5000.00005
R39 N39 N79 5000.00005
R40 N40 N80 5000.00005
R41 N41 N81 10000.0
R42 N42 N82 10000.0
R43 N43 N83 10000.0
R44 N44 N84 10000.0
R45 N45 N85 10000.0
R46 N46 N86 10000.0
R47 N47 N87 10000.0
R48 N48 N88 10000.0
R49 N49 N89 10000.0
R50 N50 N90 10000.0
R51 N51 N91 10000.0
R52 N52 N92 10000.0
R53 N53 N93 10000.0
R54 N54 N94 10000.0
R55 N55 N95 10000.0
R56 N56 N96 10000.0
R57 N57 N97 10000.0
R58 N58 N98 10000.0
R59 N59 N99 10000.0
R60 N60 N100 10000.0
R61 N61 N101 10000.0
R62 N62 N102 10000.0
R63 N63 N103 10.0
R64 N64 N104 10000.0
R65 N65 N105 10000.0
R66 N66 N106 10000.0
R67 N67 N107 10000.0
R68 N68 N108 10000.0
R69 N69 N109 10000.0
R70 N70 N110 10000.0
R71 N71 N111 10000.0
R72 N72 N112 10000.0
R73 N73 N113 10000.0
R74 N74 N114 10000.0
R75 N75 N115 10000.0
R76 N76 N116 10000.0
R77 N77 N117 10000.0
R78 N78 N118 10000.0
R79 N79 N119 10000.0
R80 N80 N120 10000.0
R81 N81 N121 10000.0
R82 N82 N122 10000.0
R83 N83 N123 10000.0
R84 N84 N124 10000.0
R85 N85 N125 10000.0
R86 N86 N126 10000.0
R87 N87 N127 10000.0
R88 N88 N128 10000.0
R89 N89 N129 10000.0
R90 N90 N130 10000.0
R91 N91 N131 10000.0
R92 N92 N132 10000.0
R93 N93 N133 10000.0
R94 N94 N134 10000.0
R95 N95 N135 10000.0
R96 N96 N136 10000.0
R97 N97 N137 10000.0
R98 N98 N138 10000.0
R99 N99 N139 10000.0
R100 N100 N140 10000.0
R101 N101 N141 10000.0
R102 N102 N142 10000.0
R103 N103 N143 10.0
R104 N104 N144 10000.0
R105 N105 N145 10000.0
R106 N106 N146 10000.0
R107 N107 N147 10000.0
R108 N108 N148 10000.0
R109 N109 N149 10000.0
R110 N110 N150 10000.0
R111 N111 N151 10000.0
R112 N112 N152 10000.0
R113 N113 N153 10000.0
R114 N114 N154 10000.0
R115 N115 N155 10000.0
R116 N116 N156 10000.0
R117 N117 N157 10000.0
R118 N118 N158 10000.0
R119 N119 N159 10000.0
R120 N120 N160 10000.0
R121 N121 N161 10000.0
R122 N122 N162 10000.0
R123 N123 N163 10000.0
R124 N124 N164 10000.0
R125 N125 N165 10000.0
R126 N126 N166 10000.0
R127 N127 N167 10000.0
R128 N128 N168 10000.0
R129 N129 N169 10000.0
R130 N130 N170 10000.0
R131 N131 N171 10000.0
R132 N132 N172 10000.0
R133 N133 N173 10000.0
R134 N134 N174 10000.0
R135 N135 N175 10000.0
R136 N136 N176 10000.0
R137 N137 N177 10000.0
R138 N138 N178 10000.0
R139 N139 N179 10000.0
R140 N140 N180 10000.0
R141 N141 N181 10000.0
R142 N142 N182 5005.0
R143 N143 N183 10.0
R144 N144 N184 10000.0
R145 N145 N185 10000.0
R146 N146 N186 10000.0
R147 N147 N187 10000.0
R148 N148 N188 10000.0
R149 N149 N189 10000.0
R150 N150 N190 10000.0
R151 N151 N191 10000.0
R152 N152 N192 10000.0
R153 N153 N193 10000.0
R154 N154 N194 10000.0
R155 N155 N195 10000.0
R156 N156 N196 10000.0
R157 N157 N197 10000.0
R158 N158 N198 10000.0
R159 N159 N199 10000.0
R160 N160 N200 10000.0
R161 N161 N201 10000.0
R162 N162 N202 10000.0
R163 N163 N203 10000.0
R164 N164 N204 10000.0
R165 N165 N205 10000.0
R166 N166 N206 10000.0
R167 N167 N207 10000.0
R168 N168 N208 10000.0
R169 N169 N209 10000.0
R170 N170 N210 10000.0
R171 N171 N211 10000.0
R172 N172 N212 10000.0
R173 N173 N213 10000.0
R174 N174 N214 10000.0
R175 N175 N215 10000.0
R176 N176 N216 10000.0
R177 N177 N217 10000.0
R178 N178 N218 10000.0
R179 N179 N219 5005.0
R180 N180 N220 5005.0
R181 N181 N221 5005.0
R182 N182 N222 5005.0
R183 N183 N223 10.0
R184 N184 N224 5005.0
R185 N185 N225 10000.0
R186 N186 N226 10000.0
R187 N187 N227 10000.0
R188 N188 N228 10000.0
R189 N189 N229 10000.0
R190 N190 N230 10000.0
R191 N191 N231 10000.0
R192 N192 N232 10000.0
R193 N193 N233 10000.0
R194 N194 N234 10000.0
R195 N195 N235 10000.0
R196 N196 N236 10000.0
R197 N197 N237 10000.0
R198 N198 N238 10000.0
R199 N199 N239 10000.0
R200 N200 N240 10000.0
R201 N201 N241 10000.0
R202 N202 N242 10000.0
R203 N203 N243 10000.0
R204 N204 N244 10000.0
R205 N205 N245 10000.0
R206 N206 N246 10000.0
R207 N207 N247 10000.0
R208 N208 N248 10000.0
R209 N209 N249 10000.0
R210 N210 N250 10000.0
R211 N211 N251 10000.0
R212 N212 N252 10000.0
R213 N213 N253 10000.0
R214 N214 N254 10000.0
R215 N215 N255 10000.0
R216 N216 N256 10000.0
R217 N217 N257 10000.0
R218 N218 N258 10000.0
R219 N219 N259 5005.0
R220 N220 N260 10.0
R221 N221 N261 10.0
R222 N222 N262 5005.0
R223 N223 N263 10.0
R224 N224 N264 5005.0
R225 N225 N265 10000.0
R226 N226 N266 10000.0
R227 N227 N267 10000.0
R228 N228 N268 10000.0
R229 N229 N269 10000.0
R230 N230 N270 10000.0
R231 N231 N271 10000.0
R232 N232 N272 10000.0
R233 N233 N273 10000.0
R234 N234 N274 10000.0
R235 N235 N275 10000.0
R236 N236 N276 10000.0
R237 N237 N277 10000.0
R238 N238 N278 10000.0
R239 N239 N279 10000.0
R240 N240 N280 10000.0
R241 N241 N281 10000.0
R242 N242 N282 10000.0
R243 N243 N283 10000.0
R244 N244 N284 10000.0
R245 N245 N285 10000.0
R246 N246 N286 10000.0
R247 N247 N287 10000.0
R248 N248 N288 10000.0
R249 N249 N289 10000.0
R250 N250 N290 10000.0
R251 N251 N291 10000.0
R252 N252 N292 10000.0
R253 N253 N293 10000.0
R254 N254 N294 10000.0
R255 N255 N295 10000.0
R256 N256 N296 10000.0
R257 N257 N297 10000.0
R258 N258 N298 10000.0
R259 N259 N299 10000.0
R260 N260 N300 10.0
R261 N261 N301 10.0
R262 N262 N302 10.0
R263 N263 N303 5005.0
R264 N264 N304 10000.0
R265 N265 N305 10000.0
R266 N266 N306 10000.0
R267 N267 N307 10000.0
R268 N268 N308 10000.0
R269 N269 N309 10000.0
R270 N270 N310 10000.0
R271 N271 N311 10000.0
R272 N272 N312 10000.0
R273 N273 N313 10000.0
R274 N274 N314 10000.0
R275 N275 N315 10000.0
R276 N276 N316 10000.0
R277 N277 N317 10000.0
R278 N278 N318 10000.0
R279 N279 N319 10000.0
R280 N280 N320 10000.0
R281 N281 N321 10000.0
R282 N282 N322 10000.0
R283 N283 N323 10000.0
R284 N284 N324 10000.0
R285 N285 N325 10000.0
R286 N286 N326 10000.0
R287 N287 N327 10000.0
R288 N288 N328 10000.0
R289 N289 N329 10000.0
R290 N290 N330 10000.0
R291 N291 N331 10000.0
R292 N292 N332 10000.0
R293 N293 N333 10000.0
R294 N294 N334 10000.0
R295 N295 N335 10000.0
R296 N296 N336 10000.0
R297 N297 N337 10000.0
R298 N298 N338 10000.0
R299 N299 N339 5005.0
R300 N300 N340 5005.0
R301 N301 N341 5005.0
R302 N302 N342 10.0
R303 N303 N343 5005.0
R304 N304 N344 10000.0
R305 N305 N345 10000.0
R306 N306 N346 10000.0
R307 N307 N347 10000.0
R308 N308 N348 10000.0
R309 N309 N349 10000.0
R310 N310 N350 10000.0
R311 N311 N351 10000.0
R312 N312 N352 10000.0
R313 N313 N353 10000.0
R314 N314 N354 10000.0
R315 N315 N355 10000.0
R316 N316 N356 10000.0
R317 N317 N357 10000.0
R318 N318 N358 10000.0
R319 N319 N359 10000.0
R320 N320 N360 10000.0
R321 N321 N361 10000.0
R322 N322 N362 10000.0
R323 N323 N363 10000.0
R324 N324 N364 10000.0
R325 N325 N365 10000.0
R326 N326 N366 10000.0
R327 N327 N367 10000.0
R328 N328 N368 10000.0
R329 N329 N369 10000.0
R330 N330 N370 10000.0
R331 N331 N371 10000.0
R332 N332 N372 10000.0
R333 N333 N373 10000.0
R334 N334 N374 10000.0
R335 N335 N375 10000.0
R336 N336 N376 10000.0
R337 N337 N377 10000.0
R338 N338 N378 10000.0
R339 N339 N379 10.0
R340 N340 N380 10000.0
R341 N341 N381 10000.0
R342 N342 N382 10.0
R343 N343 N383 10.0
R344 N344 N384 10000.0
R345 N345 N385 10000.0
R346 N346 N386 10000.0
R347 N347 N387 10000.0
R348 N348 N388 10000.0
R349 N349 N389 10000.0
R350 N350 N390 10000.0
R351 N351 N391 10000.0
R352 N352 N392 10000.0
R353 N353 N393 10000.0
R354 N354 N394 10000.0
R355 N355 N395 10000.0
R356 N356 N396 10000.0
R357 N357 N397 10000.0
R358 N358 N398 10000.0
R359 N359 N399 10000.0
R360 N360 N400 10000.0
R361 N361 N401 10000.0
R362 N362 N402 10000.0
R363 N363 N403 10000.0
R364 N364 N404 10000.0
R365 N365 N405 10000.0
R366 N366 N406 10000.0
R367 N367 N407 10000.0
R368 N368 N408 10000.0
R369 N369 N409 10000.0
R370 N370 N410 10000.0
R371 N371 N411 10000.0
R372 N372 N412 10000.0
R373 N373 N413 10000.0
R374 N374 N414 10000.0
R375 N375 N415 10000.0
R376 N376 N416 10000.0
R377 N377 N417 10000.0
R378 N378 N418 10000.0
R379 N379 N419 10.0
R380 N380 N420 5005.0
R381 N381 N421 10000.0
R382 N382 N422 10.0
R383 N383 N423 10.0
R384 N384 N424 5005.0
R385 N385 N425 10000.0
R386 N386 N426 10000.0
R387 N387 N427 10000.0
R388 N388 N428 10000.0
R389 N389 N429 10000.0
R390 N390 N430 10000.0
R391 N391 N431 10000.0
R392 N392 N432 10000.0
R393 N393 N433 10000.0
R394 N394 N434 10000.0
R395 N395 N435 10000.0
R396 N396 N436 10000.0
R397 N397 N437 10000.0
R398 N398 N438 10000.0
R399 N399 N439 10000.0
R400 N400 N440 10000.0
R401 N401 N441 10000.0
R402 N402 N442 10000.0
R403 N403 N443 10000.0
R404 N404 N444 10000.0
R405 N405 N445 10000.0
R406 N406 N446 10000.0
R407 N407 N447 10000.0
R408 N408 N448 10000.0
R409 N409 N449 10000.0
R410 N410 N450 10000.0
R411 N411 N451 10000.0
R412 N412 N452 10000.0
R413 N413 N453 10000.0
R414 N414 N454 10000.0
R415 N415 N455 10000.0
R416 N416 N456 10000.0
R417 N417 N457 10000.0
R418 N418 N458 10000.0
R419 N419 N459 5005.0
R420 N420 N460 10.0
R421 N421 N461 5005.0
R422 N422 N462 5005.0
R423 N423 N463 10.0
R424 N424 N464 5005.0
R425 N425 N465 10000.0
R426 N426 N466 10000.0
R427 N427 N467 10000.0
R428 N428 N468 10000.0
R429 N429 N469 10000.0
R430 N430 N470 10000.0
R431 N431 N471 10000.0
R432 N432 N472 10000.0
R433 N433 N473 10000.0
R434 N434 N474 10000.0
R435 N435 N475 10000.0
R436 N436 N476 10000.0
R437 N437 N477 10000.0
R438 N438 N478 10000.0
R439 N439 N479 10000.0
R440 N440 N480 10000.0
R441 N441 N481 10000.0
R442 N442 N482 10000.0
R443 N443 N483 10000.0
R444 N444 N484 10000.0
R445 N445 N485 10000.0
R446 N446 N486 10000.0
R447 N447 N487 10000.0
R448 N448 N488 10000.0
R449 N449 N489 10000.0
R450 N450 N490 10000.0
R451 N451 N491 10000.0
R452 N452 N492 10000.0
R453 N453 N493 10000.0
R454 N454 N494 10000.0
R455 N455 N495 10000.0
R456 N456 N496 10000.0
R457 N457 N497 10000.0
R458 N458 N498 10000.0
R459 N459 N499 10000.0
R460 N460 N500 10.0
R461 N461 N501 10.0
R462 N462 N502 5005.0
R463 N463 N503 10.0
R464 N464 N504 10000.0
R465 N465 N505 10000.0
R466 N466 N506 10000.0
R467 N467 N507 10000.0
R468 N468 N508 10000.0
R469 N469 N509 10000.0
R470 N470 N510 10000.0
R471 N471 N511 10000.0
R472 N472 N512 10000.0
R473 N473 N513 10000.0
R474 N474 N514 10000.0
R475 N475 N515 10000.0
R476 N476 N516 10000.0
R477 N477 N517 10000.0
R478 N478 N518 10000.0
R479 N479 N519 10000.0
R480 N480 N520 10000.0
R481 N481 N521 10000.0
R482 N482 N522 10000.0
R483 N483 N523 10000.0
R484 N484 N524 10000.0
R485 N485 N525 10000.0
R486 N486 N526 10000.0
R487 N487 N527 10000.0
R488 N488 N528 10000.0
R489 N489 N529 10000.0
R490 N490 N530 10000.0
R491 N491 N531 10000.0
R492 N492 N532 10000.0
R493 N493 N533 10000.0
R494 N494 N534 10000.0
R495 N495 N535 10000.0
R496 N496 N536 10000.0
R497 N497 N537 10000.0
R498 N498 N538 10000.0
R499 N499 N539 10000.0
R500 N500 N540 5005.0
R501 N501 N541 10.0
R502 N502 N542 10.0
R503 N503 N543 5005.0
R504 N504 N544 10000.0
R505 N505 N545 10000.0
R506 N506 N546 10000.0
R507 N507 N547 10000.0
R508 N508 N548 10000.0
R509 N509 N549 10000.0
R510 N510 N550 10000.0
R511 N511 N551 10000.0
R512 N512 N552 10000.0
R513 N513 N553 10000.0
R514 N514 N554 10000.0
R515 N515 N555 10000.0
R516 N516 N556 10000.0
R517 N517 N557 10000.0
R518 N518 N558 10000.0
R519 N519 N559 10000.0
R520 N520 N560 10000.0
R521 N521 N561 10000.0
R522 N522 N562 10000.0
R523 N523 N563 10000.0
R524 N524 N564 10000.0
R525 N525 N565 10000.0
R526 N526 N566 10000.0
R527 N527 N567 10000.0
R528 N528 N568 10000.0
R529 N529 N569 10000.0
R530 N530 N570 10000.0
R531 N531 N571 10000.0
R532 N532 N572 10000.0
R533 N533 N573 10000.0
R534 N534 N574 10000.0
R535 N535 N575 10000.0
R536 N536 N576 10000.0
R537 N537 N577 10000.0
R538 N538 N578 10000.0
R539 N539 N579 10000.0
R540 N540 N580 10000.0
R541 N541 N581 10.0
R542 N542 N582 10.0
R543 N543 N583 10000.0
R544 N544 N584 10000.0
R545 N545 N585 10000.0
R546 N546 N586 10000.0
R547 N547 N587 10000.0
R548 N548 N588 10000.0
R549 N549 N589 10000.0
R550 N550 N590 10000.0
R551 N551 N591 10000.0
R552 N552 N592 10000.0
R553 N553 N593 10000.0
R554 N554 N594 10000.0
R555 N555 N595 10000.0
R556 N556 N596 10000.0
R557 N557 N597 10000.0
R558 N558 N598 10000.0
R559 N559 N599 10000.0
R560 N560 N600 10000.0
R561 N561 N601 10000.0
R562 N562 N602 10000.0
R563 N563 N603 10000.0
R564 N564 N604 10000.0
R565 N565 N605 10000.0
R566 N566 N606 10000.0
R567 N567 N607 10000.0
R568 N568 N608 10000.0
R569 N569 N609 10000.0
R570 N570 N610 10000.0
R571 N571 N611 10000.0
R572 N572 N612 10000.0
R573 N573 N613 10000.0
R574 N574 N614 10000.0
R575 N575 N615 10000.0
R576 N576 N616 10000.0
R577 N577 N617 10000.0
R578 N578 N618 10000.0
R579 N579 N619 5005.0
R580 N580 N620 10000.0
R581 N581 N621 10.0
R582 N582 N622 10.0
R583 N583 N623 10000.0
R584 N584 N624 10000.0
R585 N585 N625 10000.0
R586 N586 N626 10000.0
R587 N587 N627 10000.0
R588 N588 N628 10000.0
R589 N589 N629 10000.0
R590 N590 N630 10000.0
R591 N591 N631 10000.0
R592 N592 N632 10000.0
R593 N593 N633 10000.0
R594 N594 N634 10000.0
R595 N595 N635 10000.0
R596 N596 N636 10000.0
R597 N597 N637 10000.0
R598 N598 N638 10000.0
R599 N599 N639 10000.0
R600 N600 N640 10000.0
R601 N601 N641 10000.0
R602 N602 N642 10000.0
R603 N603 N643 10000.0
R604 N604 N644 10000.0
R605 N605 N645 10000.0
R606 N606 N646 10000.0
R607 N607 N647 10000.0
R608 N608 N648 10000.0
R609 N609 N649 10000.0
R610 N610 N650 10000.0
R611 N611 N651 10000.0
R612 N612 N652 10000.0
R613 N613 N653 10000.0
R614 N614 N654 10000.0
R615 N615 N655 10000.0
R616 N616 N656 10000.0
R617 N617 N657 10000.0
R618 N618 N658 10000.0
R619 N619 N659 10.0
R620 N620 N660 5005.0
R621 N621 N661 10.0
R622 N622 N662 5005.0
R623 N623 N663 10000.0
R624 N624 N664 10000.0
R625 N625 N665 10000.0
R626 N626 N666 10000.0
R627 N627 N667 10000.0
R628 N628 N668 10000.0
R629 N629 N669 10000.0
R630 N630 N670 10000.0
R631 N631 N671 10000.0
R632 N632 N672 10000.0
R633 N633 N673 10000.0
R634 N634 N674 10000.0
R635 N635 N675 10000.0
R636 N636 N676 10000.0
R637 N637 N677 10000.0
R638 N638 N678 10000.0
R639 N639 N679 10000.0
R640 N640 N680 10000.0
R641 N641 N681 10000.0
R642 N642 N682 10000.0
R643 N643 N683 10000.0
R644 N644 N684 10000.0
R645 N645 N685 10000.0
R646 N646 N686 10000.0
R647 N647 N687 10000.0
R648 N648 N688 10000.0
R649 N649 N689 10000.0
R650 N650 N690 10000.0
R651 N651 N691 10000.0
R652 N652 N692 10000.0
R653 N653 N693 10000.0
R654 N654 N694 10000.0
R655 N655 N695 10000.0
R656 N656 N696 10000.0
R657 N657 N697 10000.0
R658 N658 N698 10000.0
R659 N659 N699 5005.0
R660 N660 N700 10.0
R661 N661 N701 10.0
R662 N662 N702 5005.0
R663 N663 N703 10000.0
R664 N664 N704 10000.0
R665 N665 N705 10000.0
R666 N666 N706 10000.0
R667 N667 N707 10000.0
R668 N668 N708 10000.0
R669 N669 N709 10000.0
R670 N670 N710 10000.0
R671 N671 N711 10000.0
R672 N672 N712 10000.0
R673 N673 N713 10000.0
R674 N674 N714 10000.0
R675 N675 N715 10000.0
R676 N676 N716 10000.0
R677 N677 N717 10000.0
R678 N678 N718 10000.0
R679 N679 N719 10000.0
R680 N680 N720 10000.0
R681 N681 N721 10000.0
R682 N682 N722 10000.0
R683 N683 N723 10000.0
R684 N684 N724 10000.0
R685 N685 N725 10000.0
R686 N686 N726 10000.0
R687 N687 N727 10000.0
R688 N688 N728 10000.0
R689 N689 N729 10000.0
R690 N690 N730 10000.0
R691 N691 N731 10000.0
R692 N692 N732 10000.0
R693 N693 N733 10000.0
R694 N694 N734 10000.0
R695 N695 N735 10000.0
R696 N696 N736 10000.0
R697 N697 N737 10000.0
R698 N698 N738 10000.0
R699 N699 N739 10000.0
R700 N700 N740 10.0
R701 N701 N741 5005.0
R702 N702 N742 10.0
R703 N703 N743 10000.0
R704 N704 N744 10000.0
R705 N705 N745 10000.0
R706 N706 N746 10000.0
R707 N707 N747 10000.0
R708 N708 N748 10000.0
R709 N709 N749 10000.0
R710 N710 N750 10000.0
R711 N711 N751 10000.0
R712 N712 N752 10000.0
R713 N713 N753 10000.0
R714 N714 N754 10000.0
R715 N715 N755 10000.0
R716 N716 N756 10000.0
R717 N717 N757 10000.0
R718 N718 N758 10000.0
R719 N719 N759 10000.0
R720 N720 N760 10000.0
R721 N721 N761 10000.0
R722 N722 N762 10000.0
R723 N723 N763 10000.0
R724 N724 N764 10000.0
R725 N725 N765 10000.0
R726 N726 N766 10000.0
R727 N727 N767 10000.0
R728 N728 N768 10000.0
R729 N729 N769 10000.0
R730 N730 N770 10000.0
R731 N731 N771 10000.0
R732 N732 N772 10000.0
R733 N733 N773 10000.0
R734 N734 N774 10000.0
R735 N735 N775 10000.0
R736 N736 N776 10000.0
R737 N737 N777 10000.0
R738 N738 N778 10000.0
R739 N739 N779 5005.0
R740 N740 N780 10.0
R741 N741 N781 10000.0
R742 N742 N782 10.0
R743 N743 N783 5005.0
R744 N744 N784 10000.0
R745 N745 N785 10000.0
R746 N746 N786 10000.0
R747 N747 N787 10000.0
R748 N748 N788 10000.0
R749 N749 N789 10000.0
R750 N750 N790 10000.0
R751 N751 N791 10000.0
R752 N752 N792 10000.0
R753 N753 N793 10000.0
R754 N754 N794 10000.0
R755 N755 N795 10000.0
R756 N756 N796 10000.0
R757 N757 N797 10000.0
R758 N758 N798 10000.0
R759 N759 N799 10000.0
R760 N760 N800 10000.0
R761 N761 N801 10000.0
R762 N762 N802 10000.0
R763 N763 N803 10000.0
R764 N764 N804 10000.0
R765 N765 N805 10000.0
R766 N766 N806 10000.0
R767 N767 N807 10000.0
R768 N768 N808 10000.0
R769 N769 N809 10000.0
R770 N770 N810 10000.0
R771 N771 N811 10000.0
R772 N772 N812 10000.0
R773 N773 N813 10000.0
R774 N774 N814 10000.0
R775 N775 N815 10000.0
R776 N776 N816 10000.0
R777 N777 N817 10000.0
R778 N778 N818 10000.0
R779 N779 N819 10.0
R780 N780 N820 10.0
R781 N781 N821 10000.0
R782 N782 N822 5005.0
R783 N783 N823 10.0
R784 N784 N824 10000.0
R785 N785 N825 10000.0
R786 N786 N826 10000.0
R787 N787 N827 10000.0
R788 N788 N828 10000.0
R789 N789 N829 10000.0
R790 N790 N830 10000.0
R791 N791 N831 10000.0
R792 N792 N832 10000.0
R793 N793 N833 10000.0
R794 N794 N834 10000.0
R795 N795 N835 10000.0
R796 N796 N836 10000.0
R797 N797 N837 10000.0
R798 N798 N838 10000.0
R799 N799 N839 10000.0
R800 N800 N840 10000.0
R801 N801 N841 10000.0
R802 N802 N842 10000.0
R803 N803 N843 10000.0
R804 N804 N844 10000.0
R805 N805 N845 10000.0
R806 N806 N846 10000.0
R807 N807 N847 10000.0
R808 N808 N848 10000.0
R809 N809 N849 10000.0
R810 N810 N850 10000.0
R811 N811 N851 10000.0
R812 N812 N852 10000.0
R813 N813 N853 10000.0
R814 N814 N854 10000.0
R815 N815 N855 10000.0
R816 N816 N856 10000.0
R817 N817 N857 10000.0
R818 N818 N858 5005.0
R819 N819 N859 10.0
R820 N820 N860 5005.0
R821 N821 N861 10000.0
R822 N822 N862 5005.0
R823 N823 N863 10.0
R824 N824 N864 10000.0
R825 N825 N865 10000.0
R826 N826 N866 10000.0
R827 N827 N867 10000.0
R828 N828 N868 10000.0
R829 N829 N869 10000.0
R830 N830 N870 10000.0
R831 N831 N871 10000.0
R832 N832 N872 10000.0
R833 N833 N873 10000.0
R834 N834 N874 10000.0
R835 N835 N875 10000.0
R836 N836 N876 10000.0
R837 N837 N877 10000.0
R838 N838 N878 10000.0
R839 N839 N879 10000.0
R840 N840 N880 10000.0
R841 N841 N881 10000.0
R842 N842 N882 10000.0
R843 N843 N883 10000.0
R844 N844 N884 10000.0
R845 N845 N885 10000.0
R846 N846 N886 10000.0
R847 N847 N887 10000.0
R848 N848 N888 10000.0
R849 N849 N889 10000.0
R850 N850 N890 10000.0
R851 N851 N891 10000.0
R852 N852 N892 10000.0
R853 N853 N893 10000.0
R854 N854 N894 10000.0
R855 N855 N895 10000.0
R856 N856 N896 10000.0
R857 N857 N897 10000.0
R858 N858 N898 5005.0
R859 N859 N899 10.0
R860 N860 N900 10000.0
R861 N861 N901 10000.0
R862 N862 N902 10.0
R863 N863 N903 10.0
R864 N864 N904 10000.0
R865 N865 N905 10000.0
R866 N866 N906 10000.0
R867 N867 N907 10000.0
R868 N868 N908 10000.0
R869 N869 N909 10000.0
R870 N870 N910 10000.0
R871 N871 N911 10000.0
R872 N872 N912 10000.0
R873 N873 N913 10000.0
R874 N874 N914 10000.0
R875 N875 N915 10000.0
R876 N876 N916 10000.0
R877 N877 N917 10000.0
R878 N878 N918 10000.0
R879 N879 N919 10000.0
R880 N880 N920 10000.0
R881 N881 N921 10000.0
R882 N882 N922 10000.0
R883 N883 N923 10000.0
R884 N884 N924 10000.0
R885 N885 N925 10000.0
R886 N886 N926 10000.0
R887 N887 N927 10000.0
R888 N888 N928 10000.0
R889 N889 N929 10000.0
R890 N890 N930 10000.0
R891 N891 N931 10000.0
R892 N892 N932 10000.0
R893 N893 N933 10000.0
R894 N894 N934 10000.0
R895 N895 N935 10000.0
R896 N896 N936 10000.0
R897 N897 N937 5005.0
R898 N898 N938 5005.0
R899 N899 N939 10.0
R900 N900 N940 10000.0
R901 N901 N941 10000.0
R902 N902 N942 5005.0
R903 N903 N943 10.0
R904 N904 N944 10000.0
R905 N905 N945 10000.0
R906 N906 N946 10000.0
R907 N907 N947 10000.0
R908 N908 N948 10000.0
R909 N909 N949 10000.0
R910 N910 N950 10000.0
R911 N911 N951 10000.0
R912 N912 N952 10000.0
R913 N913 N953 10000.0
R914 N914 N954 10000.0
R915 N915 N955 10000.0
R916 N916 N956 10000.0
R917 N917 N957 10000.0
R918 N918 N958 10000.0
R919 N919 N959 10000.0
R920 N920 N960 10000.0
R921 N921 N961 10000.0
R922 N922 N962 10000.0
R923 N923 N963 10000.0
R924 N924 N964 10000.0
R925 N925 N965 10000.0
R926 N926 N966 10000.0
R927 N927 N967 10000.0
R928 N928 N968 10000.0
R929 N929 N969 10000.0
R930 N930 N970 10000.0
R931 N931 N971 10000.0
R932 N932 N972 10000.0
R933 N933 N973 10000.0
R934 N934 N974 10000.0
R935 N935 N975 10000.0
R936 N936 N976 10000.0
R937 N937 N977 5005.0
R938 N938 N978 5005.0
R939 N939 N979 10.0
R940 N940 N980 10000.0
R941 N941 N981 5005.0
R942 N942 N982 5005.0
R943 N943 N983 10.0
R944 N944 N984 10000.0
R945 N945 N985 10000.0
R946 N946 N986 10000.0
R947 N947 N987 10000.0
R948 N948 N988 10000.0
R949 N949 N989 10000.0
R950 N950 N990 10000.0
R951 N951 N991 10000.0
R952 N952 N992 10000.0
R953 N953 N993 10000.0
R954 N954 N994 10000.0
R955 N955 N995 10000.0
R956 N956 N996 10000.0
R957 N957 N997 10000.0
R958 N958 N998 10000.0
R959 N959 N999 10000.0
R960 N960 N1000 10000.0
R961 N961 N1001 10000.0
R962 N962 N1002 10000.0
R963 N963 N1003 10000.0
R964 N964 N1004 10000.0
R965 N965 N1005 10000.0
R966 N966 N1006 10000.0
R967 N967 N1007 10000.0
R968 N968 N1008 10000.0
R969 N969 N1009 10000.0
R970 N970 N1010 10000.0
R971 N971 N1011 10000.0
R972 N972 N1012 10000.0
R973 N973 N1013 10000.0
R974 N974 N1014 10000.0
R975 N975 N1015 10000.0
R976 N976 N1016 10000.0
R977 N977 N1017 10000.0
R978 N978 N1018 10000.0
R979 N979 N1019 10.0
R980 N980 N1020 5005.0
R981 N981 N1021 10.0
R982 N982 N1022 10.0
R983 N983 N1023 5005.0
R984 N984 N1024 10000.0
R985 N985 N1025 10000.0
R986 N986 N1026 10000.0
R987 N987 N1027 10000.0
R988 N988 N1028 10000.0
R989 N989 N1029 10000.0
R990 N990 N1030 10000.0
R991 N991 N1031 10000.0
R992 N992 N1032 10000.0
R993 N993 N1033 10000.0
R994 N994 N1034 10000.0
R995 N995 N1035 10000.0
R996 N996 N1036 10000.0
R997 N997 N1037 10000.0
R998 N998 N1038 10000.0
R999 N999 N1039 10000.0
R1000 N1000 N1040 10000.0
R1001 N1001 N1041 10000.0
R1002 N1002 N1042 10000.0
R1003 N1003 N1043 10000.0
R1004 N1004 N1044 10000.0
R1005 N1005 N1045 10000.0
R1006 N1006 N1046 10000.0
R1007 N1007 N1047 10000.0
R1008 N1008 N1048 10000.0
R1009 N1009 N1049 10000.0
R1010 N1010 N1050 10000.0
R1011 N1011 N1051 10000.0
R1012 N1012 N1052 10000.0
R1013 N1013 N1053 10000.0
R1014 N1014 N1054 10000.0
R1015 N1015 N1055 10000.0
R1016 N1016 N1056 10000.0
R1017 N1017 N1057 10000.0
R1018 N1018 N1058 5005.0
R1019 N1019 N1059 10.0
R1020 N1020 N1060 5005.0
R1021 N1021 N1061 10.0
R1022 N1022 N1062 10.0
R1023 N1023 N1063 10000.0
R1024 N1024 N1064 10000.0
R1025 N1025 N1065 10000.0
R1026 N1026 N1066 10000.0
R1027 N1027 N1067 10000.0
R1028 N1028 N1068 10000.0
R1029 N1029 N1069 10000.0
R1030 N1030 N1070 10000.0
R1031 N1031 N1071 10000.0
R1032 N1032 N1072 10000.0
R1033 N1033 N1073 10000.0
R1034 N1034 N1074 10000.0
R1035 N1035 N1075 10000.0
R1036 N1036 N1076 10000.0
R1037 N1037 N1077 10000.0
R1038 N1038 N1078 10000.0
R1039 N1039 N1079 10000.0
R1040 N1040 N1080 10000.0
R1041 N1041 N1081 10000.0
R1042 N1042 N1082 10000.0
R1043 N1043 N1083 10000.0
R1044 N1044 N1084 10000.0
R1045 N1045 N1085 10000.0
R1046 N1046 N1086 10000.0
R1047 N1047 N1087 10000.0
R1048 N1048 N1088 10000.0
R1049 N1049 N1089 10000.0
R1050 N1050 N1090 10000.0
R1051 N1051 N1091 10000.0
R1052 N1052 N1092 10000.0
R1053 N1053 N1093 10000.0
R1054 N1054 N1094 10000.0
R1055 N1055 N1095 10000.0
R1056 N1056 N1096 10000.0
R1057 N1057 N1097 10000.0
R1058 N1058 N1098 5005.0
R1059 N1059 N1099 10.0
R1060 N1060 N1100 5005.0
R1061 N1061 N1101 10.0
R1062 N1062 N1102 10.0
R1063 N1063 N1103 10000.0
R1064 N1064 N1104 10000.0
R1065 N1065 N1105 10000.0
R1066 N1066 N1106 10000.0
R1067 N1067 N1107 10000.0
R1068 N1068 N1108 10000.0
R1069 N1069 N1109 10000.0
R1070 N1070 N1110 10000.0
R1071 N1071 N1111 10000.0
R1072 N1072 N1112 10000.0
R1073 N1073 N1113 10000.0
R1074 N1074 N1114 10000.0
R1075 N1075 N1115 10000.0
R1076 N1076 N1116 10000.0
R1077 N1077 N1117 10000.0
R1078 N1078 N1118 10000.0
R1079 N1079 N1119 10000.0
R1080 N1080 N1120 10000.0
R1081 N1081 N1121 10000.0
R1082 N1082 N1122 10000.0
R1083 N1083 N1123 10000.0
R1084 N1084 N1124 10000.0
R1085 N1085 N1125 10000.0
R1086 N1086 N1126 10000.0
R1087 N1087 N1127 10000.0
R1088 N1088 N1128 10000.0
R1089 N1089 N1129 10000.0
R1090 N1090 N1130 10000.0
R1091 N1091 N1131 10000.0
R1092 N1092 N1132 10000.0
R1093 N1093 N1133 10000.0
R1094 N1094 N1134 10000.0
R1095 N1095 N1135 10000.0
R1096 N1096 N1136 10000.0
R1097 N1097 N1137 10000.0
R1098 N1098 N1138 10000.0
R1099 N1099 N1139 10.0
R1100 N1100 N1140 5005.0
R1101 N1101 N1141 10.0
R1102 N1102 N1142 5005.0
R1103 N1103 N1143 10000.0
R1104 N1104 N1144 10000.0
R1105 N1105 N1145 10000.0
R1106 N1106 N1146 10000.0
R1107 N1107 N1147 10000.0
R1108 N1108 N1148 10000.0
R1109 N1109 N1149 10000.0
R1110 N1110 N1150 10000.0
R1111 N1111 N1151 10000.0
R1112 N1112 N1152 10000.0
R1113 N1113 N1153 10000.0
R1114 N1114 N1154 10000.0
R1115 N1115 N1155 10000.0
R1116 N1116 N1156 10000.0
R1117 N1117 N1157 10000.0
R1118 N1118 N1158 10000.0
R1119 N1119 N1159 10000.0
R1120 N1120 N1160 10000.0
R1121 N1121 N1161 10000.0
R1122 N1122 N1162 10000.0
R1123 N1123 N1163 10000.0
R1124 N1124 N1164 10000.0
R1125 N1125 N1165 10000.0
R1126 N1126 N1166 10000.0
R1127 N1127 N1167 10000.0
R1128 N1128 N1168 10000.0
R1129 N1129 N1169 10000.0
R1130 N1130 N1170 10000.0
R1131 N1131 N1171 10000.0
R1132 N1132 N1172 10000.0
R1133 N1133 N1173 10000.0
R1134 N1134 N1174 10000.0
R1135 N1135 N1175 10000.0
R1136 N1136 N1176 10000.0
R1137 N1137 N1177 10000.0
R1138 N1138 N1178 5005.0
R1139 N1139 N1179 10.0
R1140 N1140 N1180 10000.0
R1141 N1141 N1181 10.0
R1142 N1142 N1182 10000.0
R1143 N1143 N1183 10000.0
R1144 N1144 N1184 10000.0
R1145 N1145 N1185 10000.0
R1146 N1146 N1186 10000.0
R1147 N1147 N1187 10000.0
R1148 N1148 N1188 10000.0
R1149 N1149 N1189 10000.0
R1150 N1150 N1190 10000.0
R1151 N1151 N1191 10000.0
R1152 N1152 N1192 10000.0
R1153 N1153 N1193 10000.0
R1154 N1154 N1194 10000.0
R1155 N1155 N1195 10000.0
R1156 N1156 N1196 10000.0
R1157 N1157 N1197 10000.0
R1158 N1158 N1198 10000.0
R1159 N1159 N1199 10000.0
R1160 N1160 N1200 10000.0
R1161 N1161 N1201 10000.0
R1162 N1162 N1202 10000.0
R1163 N1163 N1203 10000.0
R1164 N1164 N1204 10000.0
R1165 N1165 N1205 10000.0
R1166 N1166 N1206 10000.0
R1167 N1167 N1207 10000.0
R1168 N1168 N1208 10000.0
R1169 N1169 N1209 10000.0
R1170 N1170 N1210 10000.0
R1171 N1171 N1211 10000.0
R1172 N1172 N1212 10000.0
R1173 N1173 N1213 10000.0
R1174 N1174 N1214 10000.0
R1175 N1175 N1215 10000.0
R1176 N1176 N1216 10000.0
R1177 N1177 N1217 10000.0
R1178 N1178 N1218 5005.0
R1179 N1179 N1219 10.0
R1180 N1180 N1220 10000.0
R1181 N1181 N1221 10.0
R1182 N1182 N1222 10000.0
R1183 N1183 N1223 10000.0
R1184 N1184 N1224 5005.0
R1185 N1185 N1225 5005.0
R1186 N1186 N1226 10000.0
R1187 N1187 N1227 10000.0
R1188 N1188 N1228 10000.0
R1189 N1189 N1229 10000.0
R1190 N1190 N1230 10000.0
R1191 N1191 N1231 10000.0
R1192 N1192 N1232 10000.0
R1193 N1193 N1233 10000.0
R1194 N1194 N1234 10000.0
R1195 N1195 N1235 10000.0
R1196 N1196 N1236 10000.0
R1197 N1197 N1237 10000.0
R1198 N1198 N1238 10000.0
R1199 N1199 N1239 10000.0
R1200 N1200 N1240 10000.0
R1201 N1201 N1241 10000.0
R1202 N1202 N1242 10000.0
R1203 N1203 N1243 10000.0
R1204 N1204 N1244 10000.0
R1205 N1205 N1245 10000.0
R1206 N1206 N1246 10000.0
R1207 N1207 N1247 10000.0
R1208 N1208 N1248 10000.0
R1209 N1209 N1249 10000.0
R1210 N1210 N1250 10000.0
R1211 N1211 N1251 10000.0
R1212 N1212 N1252 10000.0
R1213 N1213 N1253 10000.0
R1214 N1214 N1254 5005.0
R1215 N1215 N1255 5005.0
R1216 N1216 N1256 5005.0
R1217 N1217 N1257 5005.0
R1218 N1218 N1258 5005.0
R1219 N1219 N1259 10.0
R1220 N1220 N1260 5005.0
R1221 N1221 N1261 10.0
R1222 N1222 N1262 5005.0
R1223 N1223 N1263 5005.0
R1224 N1224 N1264 10.0
R1225 N1225 N1265 10.0
R1226 N1226 N1266 10000.0
R1227 N1227 N1267 10000.0
R1228 N1228 N1268 10000.0
R1229 N1229 N1269 10000.0
R1230 N1230 N1270 10000.0
R1231 N1231 N1271 10000.0
R1232 N1232 N1272 10000.0
R1233 N1233 N1273 10000.0
R1234 N1234 N1274 10000.0
R1235 N1235 N1275 10000.0
R1236 N1236 N1276 10000.0
R1237 N1237 N1277 10000.0
R1238 N1238 N1278 10000.0
R1239 N1239 N1279 10000.0
R1240 N1240 N1280 10000.0
R1241 N1241 N1281 10000.0
R1242 N1242 N1282 10000.0
R1243 N1243 N1283 10000.0
R1244 N1244 N1284 10000.0
R1245 N1245 N1285 10000.0
R1246 N1246 N1286 10000.0
R1247 N1247 N1287 10000.0
R1248 N1248 N1288 10000.0
R1249 N1249 N1289 10000.0
R1250 N1250 N1290 10000.0
R1251 N1251 N1291 10000.0
R1252 N1252 N1292 10000.0
R1253 N1253 N1293 10000.0
R1254 N1254 N1294 10.0
R1255 N1255 N1295 10.0
R1256 N1256 N1296 5005.0
R1257 N1257 N1297 5005.0
R1258 N1258 N1298 10.0
R1259 N1259 N1299 5005.0
R1260 N1260 N1300 10.0
R1261 N1261 N1301 10.0
R1262 N1262 N1302 5005.0
R1263 N1263 N1303 5005.0
R1264 N1264 N1304 10.0
R1265 N1265 N1305 10.0
R1266 N1266 N1306 10000.0
R1267 N1267 N1307 10000.0
R1268 N1268 N1308 10000.0
R1269 N1269 N1309 10000.0
R1270 N1270 N1310 10000.0
R1271 N1271 N1311 10000.0
R1272 N1272 N1312 10000.0
R1273 N1273 N1313 10000.0
R1274 N1274 N1314 10000.0
R1275 N1275 N1315 10000.0
R1276 N1276 N1316 10000.0
R1277 N1277 N1317 10000.0
R1278 N1278 N1318 10000.0
R1279 N1279 N1319 10000.0
R1280 N1280 N1320 10000.0
R1281 N1281 N1321 10000.0
R1282 N1282 N1322 10000.0
R1283 N1283 N1323 10000.0
R1284 N1284 N1324 10000.0
R1285 N1285 N1325 10000.0
R1286 N1286 N1326 10000.0
R1287 N1287 N1327 10000.0
R1288 N1288 N1328 10000.0
R1289 N1289 N1329 10000.0
R1290 N1290 N1330 10000.0
R1291 N1291 N1331 10000.0
R1292 N1292 N1332 10000.0
R1293 N1293 N1333 10000.0
R1294 N1294 N1334 5005.0
R1295 N1295 N1335 10.0
R1296 N1296 N1336 5005.0
R1297 N1297 N1337 5005.0
R1298 N1298 N1338 10.0
R1299 N1299 N1339 10000.0
R1300 N1300 N1340 10.0
R1301 N1301 N1341 10.0
R1302 N1302 N1342 10000.0
R1303 N1303 N1343 10000.0
R1304 N1304 N1344 5005.0
R1305 N1305 N1345 10.0
R1306 N1306 N1346 10000.0
R1307 N1307 N1347 10000.0
R1308 N1308 N1348 10000.0
R1309 N1309 N1349 10000.0
R1310 N1310 N1350 10000.0
R1311 N1311 N1351 10000.0
R1312 N1312 N1352 10000.0
R1313 N1313 N1353 10000.0
R1314 N1314 N1354 10000.0
R1315 N1315 N1355 10000.0
R1316 N1316 N1356 10000.0
R1317 N1317 N1357 10000.0
R1318 N1318 N1358 10000.0
R1319 N1319 N1359 10000.0
R1320 N1320 N1360 10000.0
R1321 N1321 N1361 10000.0
R1322 N1322 N1362 10000.0
R1323 N1323 N1363 10000.0
R1324 N1324 N1364 10000.0
R1325 N1325 N1365 10000.0
R1326 N1326 N1366 10000.0
R1327 N1327 N1367 10000.0
R1328 N1328 N1368 10000.0
R1329 N1329 N1369 10000.0
R1330 N1330 N1370 10000.0
R1331 N1331 N1371 10000.0
R1332 N1332 N1372 10000.0
R1333 N1333 N1373 10000.0
R1334 N1334 N1374 10000.0
R1335 N1335 N1375 5005.0
R1336 N1336 N1376 10.0
R1337 N1337 N1377 10.0
R1338 N1338 N1378 10.0
R1339 N1339 N1379 5005.0
R1340 N1340 N1380 10.0
R1341 N1341 N1381 5005.0
R1342 N1342 N1382 10000.0
R1343 N1343 N1383 10000.0
R1344 N1344 N1384 10000.0
R1345 N1345 N1385 10.0
R1346 N1346 N1386 10000.0
R1347 N1347 N1387 10000.0
R1348 N1348 N1388 10000.0
R1349 N1349 N1389 10000.0
R1350 N1350 N1390 10000.0
R1351 N1351 N1391 10000.0
R1352 N1352 N1392 10000.0
R1353 N1353 N1393 10000.0
R1354 N1354 N1394 10000.0
R1355 N1355 N1395 10000.0
R1356 N1356 N1396 10000.0
R1357 N1357 N1397 10000.0
R1358 N1358 N1398 10000.0
R1359 N1359 N1399 10000.0
R1360 N1360 N1400 10000.0
R1361 N1361 N1401 10000.0
R1362 N1362 N1402 10000.0
R1363 N1363 N1403 10000.0
R1364 N1364 N1404 10000.0
R1365 N1365 N1405 10000.0
R1366 N1366 N1406 10000.0
R1367 N1367 N1407 10000.0
R1368 N1368 N1408 10000.0
R1369 N1369 N1409 10000.0
R1370 N1370 N1410 10000.0
R1371 N1371 N1411 10000.0
R1372 N1372 N1412 10000.0
R1373 N1373 N1413 10000.0
R1374 N1374 N1414 10000.0
R1375 N1375 N1415 10000.0
R1376 N1376 N1416 5005.0
R1377 N1377 N1417 5005.0
R1378 N1378 N1418 10.0
R1379 N1379 N1419 10.0
R1380 N1380 N1420 5005.0
R1381 N1381 N1421 10000.0
R1382 N1382 N1422 10000.0
R1383 N1383 N1423 10000.0
R1384 N1384 N1424 10000.0
R1385 N1385 N1425 10.0
R1386 N1386 N1426 10000.0
R1387 N1387 N1427 5005.0
R1388 N1388 N1428 10000.0
R1389 N1389 N1429 10000.0
R1390 N1390 N1430 10000.0
R1391 N1391 N1431 10000.0
R1392 N1392 N1432 10000.0
R1393 N1393 N1433 10000.0
R1394 N1394 N1434 10000.0
R1395 N1395 N1435 10000.0
R1396 N1396 N1436 10000.0
R1397 N1397 N1437 10000.0
R1398 N1398 N1438 10000.0
R1399 N1399 N1439 10000.0
R1400 N1400 N1440 10000.0
R1401 N1401 N1441 10000.0
R1402 N1402 N1442 10000.0
R1403 N1403 N1443 10000.0
R1404 N1404 N1444 10000.0
R1405 N1405 N1445 10000.0
R1406 N1406 N1446 10000.0
R1407 N1407 N1447 10000.0
R1408 N1408 N1448 10000.0
R1409 N1409 N1449 10000.0
R1410 N1410 N1450 10000.0
R1411 N1411 N1451 10000.0
R1412 N1412 N1452 5005.0
R1413 N1413 N1453 10000.0
R1414 N1414 N1454 10000.0
R1415 N1415 N1455 10000.0
R1416 N1416 N1456 10000.0
R1417 N1417 N1457 10000.0
R1418 N1418 N1458 10.0
R1419 N1419 N1459 10.0
R1420 N1420 N1460 10000.0
R1421 N1421 N1461 10000.0
R1422 N1422 N1462 10000.0
R1423 N1423 N1463 10000.0
R1424 N1424 N1464 10000.0
R1425 N1425 N1465 10.0
R1426 N1426 N1466 10000.0
R1427 N1427 N1467 10.0
R1428 N1428 N1468 5005.0
R1429 N1429 N1469 10000.0
R1430 N1430 N1470 10000.0
R1431 N1431 N1471 10000.0
R1432 N1432 N1472 10000.0
R1433 N1433 N1473 10000.0
R1434 N1434 N1474 10000.0
R1435 N1435 N1475 10000.0
R1436 N1436 N1476 10000.0
R1437 N1437 N1477 10000.0
R1438 N1438 N1478 10000.0
R1439 N1439 N1479 10000.0
R1440 N1440 N1480 10000.0
R1441 N1441 N1481 10000.0
R1442 N1442 N1482 10000.0
R1443 N1443 N1483 10000.0
R1444 N1444 N1484 10000.0
R1445 N1445 N1485 10000.0
R1446 N1446 N1486 10000.0
R1447 N1447 N1487 10000.0
R1448 N1448 N1488 10000.0
R1449 N1449 N1489 10000.0
R1450 N1450 N1490 10000.0
R1451 N1451 N1491 10000.0
R1452 N1452 N1492 10.0
R1453 N1453 N1493 5005.0
R1454 N1454 N1494 10000.0
R1455 N1455 N1495 10000.0
R1456 N1456 N1496 10000.0
R1457 N1457 N1497 10000.0
R1458 N1458 N1498 10.0
R1459 N1459 N1499 5005.0
R1460 N1460 N1500 10000.0
R1461 N1461 N1501 10000.0
R1462 N1462 N1502 10000.0
R1463 N1463 N1503 10000.0
R1464 N1464 N1504 5005.0
R1465 N1465 N1505 10.0
R1466 N1466 N1506 10000.0
R1467 N1467 N1507 5005.0
R1468 N1468 N1508 10.0
R1469 N1469 N1509 10000.0
R1470 N1470 N1510 10000.0
R1471 N1471 N1511 10000.0
R1472 N1472 N1512 10000.0
R1473 N1473 N1513 10000.0
R1474 N1474 N1514 10000.0
R1475 N1475 N1515 10000.0
R1476 N1476 N1516 10000.0
R1477 N1477 N1517 10000.0
R1478 N1478 N1518 10000.0
R1479 N1479 N1519 10000.0
R1480 N1480 N1520 10000.0
R1481 N1481 N1521 10000.0
R1482 N1482 N1522 10000.0
R1483 N1483 N1523 10000.0
R1484 N1484 N1524 10000.0
R1485 N1485 N1525 10000.0
R1486 N1486 N1526 10000.0
R1487 N1487 N1527 10000.0
R1488 N1488 N1528 10000.0
R1489 N1489 N1529 10000.0
R1490 N1490 N1530 10000.0
R1491 N1491 N1531 10000.0
R1492 N1492 N1532 5005.0
R1493 N1493 N1533 10.0
R1494 N1494 N1534 10000.0
R1495 N1495 N1535 10000.0
R1496 N1496 N1536 10000.0
R1497 N1497 N1537 10000.0
R1498 N1498 N1538 10.0
R1499 N1499 N1539 10000.0
R1500 N1500 N1540 10000.0
R1501 N1501 N1541 10000.0
R1502 N1502 N1542 10000.0
R1503 N1503 N1543 10000.0
R1504 N1504 N1544 10.0
R1505 N1505 N1545 10.0
R1506 N1506 N1546 5005.0
R1507 N1507 N1547 5005.0
R1508 N1508 N1548 10.0
R1509 N1509 N1549 5005.0
R1510 N1510 N1550 10000.0
R1511 N1511 N1551 10000.0
R1512 N1512 N1552 10000.0
R1513 N1513 N1553 10000.0
R1514 N1514 N1554 10000.0
R1515 N1515 N1555 10000.0
R1516 N1516 N1556 10000.0
R1517 N1517 N1557 10000.0
R1518 N1518 N1558 10000.0
R1519 N1519 N1559 10000.0
R1520 N1520 N1560 10000.0
R1521 N1521 N1561 10000.0
R1522 N1522 N1562 10000.0
R1523 N1523 N1563 10000.0
R1524 N1524 N1564 10000.0
R1525 N1525 N1565 10000.0
R1526 N1526 N1566 10000.0
R1527 N1527 N1567 10000.0
R1528 N1528 N1568 10000.0
R1529 N1529 N1569 10000.0
R1530 N1530 N1570 10000.0
R1531 N1531 N1571 10000.0
R1532 N1532 N1572 5005.0
R1533 N1533 N1573 10.0
R1534 N1534 N1574 5005.0
R1535 N1535 N1575 10000.0
R1536 N1536 N1576 10000.0
R1537 N1537 N1577 10000.0
R1538 N1538 N1578 10.0
R1539 N1539 N1579 10000.0
R1540 N1540 N1580 5005.0
R1541 N1541 N1581 5005.0
R1542 N1542 N1582 10000.0
R1543 N1543 N1583 10000.0
R1544 N1544 N1584 10.0
R1545 N1545 N1585 10.0
R1546 N1546 N1586 10.0
R1547 N1547 N1587 5005.0
R1548 N1548 N1588 5005.0
R1549 N1549 N1589 5005.0
R1550 N1550 N1590 10000.0
R1551 N1551 N1591 10000.0
R1552 N1552 N1592 5005.0
R1553 N1553 N1593 5005.0
R1554 N1554 N1594 10000.0
R1555 N1555 N1595 10000.0
R1556 N1556 N1596 10000.0
R1557 N1557 N1597 10000.0
R1558 N1558 N1598 10000.0
R1559 N1559 N1599 10000.0
R1560 N1560 N1600 10000.0
R1561 N1561 N1601 10000.0
R1562 N1562 N1602 10000.0
R1563 N1563 N1603 10000.0
R1564 N1564 N1604 10000.0
R1565 N1565 N1605 10000.0
R1566 N1566 N1606 10000.0
R1567 N1567 N1607 10000.0
R1568 N1568 N1608 10000.0
R1569 N1569 N1609 10000.0
R1570 N1570 N1610 10000.0
R1571 N1571 N1611 10000.0
R1572 N1572 N1612 5005.0
R1573 N1573 N1613 10.0
R1574 N1574 N1614 5005.0
R1575 N1575 N1615 10000.0
R1576 N1576 N1616 10000.0
R1577 N1577 N1617 10000.0
R1578 N1578 N1618 10.0
R1579 N1579 N1619 5005.0
R1580 N1580 N1620 10.0
R1581 N1581 N1621 10.0
R1582 N1582 N1622 10000.0
R1583 N1583 N1623 10000.0
R1584 N1584 N1624 10.0
R1585 N1585 N1625 5005.0
R1586 N1586 N1626 10.0
R1587 N1587 N1627 10000.0
R1588 N1588 N1628 10000.0
R1589 N1589 N1629 10000.0
R1590 N1590 N1630 10000.0
R1591 N1591 N1631 10000.0
R1592 N1592 N1632 10.0
R1593 N1593 N1633 10.0
R1594 N1594 N1634 10000.0
R1595 N1595 N1635 10000.0
R1596 N1596 N1636 10000.0
R1597 N1597 N1637 10000.0
R1598 N1598 N1638 10000.0
R1599 N1599 N1639 10000.0
R1600 N1600 N1640 10000.0
R1601 N1601 N1641 5000.00005
R1602 N1602 N1642 5000.00005
R1603 N1603 N1643 5000.00005
R1604 N1604 N1644 5000.00005
R1605 N1605 N1645 5000.00005
R1606 N1606 N1646 5000.00005
R1607 N1607 N1647 5000.00005
R1608 N1608 N1648 5000.00005
R1609 N1609 N1649 5000.00005
R1610 N1610 N1650 5000.00005
R1611 N1611 N1651 5000.00005
R1612 N1612 N1652 5000.00005
R1613 N1613 N1653 5.00005
R1614 N1614 N1654 5000.00005
R1615 N1615 N1655 5000.00005
R1616 N1616 N1656 5000.00005
R1617 N1617 N1657 5000.00005
R1618 N1618 N1658 5.00005
R1619 N1619 N1659 5.00005
R1620 N1620 N1660 5.00005
R1621 N1621 N1661 5.00005
R1622 N1622 N1662 5000.00005
R1623 N1623 N1663 5000.00005
R1624 N1624 N1664 5.00005
R1625 N1625 N1665 5000.00005
R1626 N1626 N1666 5.00005
R1627 N1627 N1667 5000.00005
R1628 N1628 N1668 5000.00005
R1629 N1629 N1669 5000.00005
R1630 N1630 N1670 5000.00005
R1631 N1631 N1671 5000.00005
R1632 N1632 N1672 5.00005
R1633 N1633 N1673 5.00005
R1634 N1634 N1674 5000.00005
R1635 N1635 N1675 5000.00005
R1636 N1636 N1676 5000.00005
R1637 N1637 N1677 5000.00005
R1638 N1638 N1678 5000.00005
R1639 N1639 N1679 5000.00005
R1640 N1640 0 5000.00005
R1641 N1 N2 0.0001
R1642 N2 N3 0.0001
R1643 N3 N4 0.0001
R1644 N4 N5 0.0001
R1645 N5 N6 0.0001
R1646 N6 N7 0.0001
R1647 N7 N8 0.0001
R1648 N8 N9 0.0001
R1649 N9 N10 0.0001
R1650 N10 N11 0.0001
R1651 N11 N12 0.0001
R1652 N12 N13 0.0001
R1653 N13 N14 0.0001
R1654 N14 N15 0.0001
R1655 N15 N16 0.0001
R1656 N16 N17 0.0001
R1657 N17 N18 0.0001
R1658 N18 N19 0.0001
R1659 N19 N20 0.0001
R1660 N20 N21 0.0001
R1661 N21 N22 0.0001
R1662 N22 N23 0.0001
R1663 N23 N24 0.0001
R1664 N24 N25 0.0001
R1665 N25 N26 0.0001
R1666 N26 N27 0.0001
R1667 N27 N28 0.0001
R1668 N28 N29 0.0001
R1669 N29 N30 0.0001
R1670 N30 N31 0.0001
R1671 N31 N32 0.0001
R1672 N32 N33 0.0001
R1673 N33 N34 0.0001
R1674 N34 N35 0.0001
R1675 N35 N36 0.0001
R1676 N36 N37 0.0001
R1677 N37 N38 0.0001
R1678 N38 N39 0.0001
R1679 N39 N40 0.0001
R1680 N41 N42 10000.0
R1681 N42 N43 10000.0
R1682 N43 N44 10000.0
R1683 N44 N45 10000.0
R1684 N45 N46 10000.0
R1685 N46 N47 10000.0
R1686 N47 N48 10000.0
R1687 N48 N49 10000.0
R1688 N49 N50 10000.0
R1689 N50 N51 10000.0
R1690 N51 N52 10000.0
R1691 N52 N53 10000.0
R1692 N53 N54 10000.0
R1693 N54 N55 10000.0
R1694 N55 N56 10000.0
R1695 N56 N57 10000.0
R1696 N57 N58 10000.0
R1697 N58 N59 10000.0
R1698 N59 N60 10000.0
R1699 N60 N61 10000.0
R1700 N61 N62 10000.0
R1701 N62 N63 5005.0
R1702 N63 N64 5005.0
R1703 N64 N65 10000.0
R1704 N65 N66 10000.0
R1705 N66 N67 10000.0
R1706 N67 N68 10000.0
R1707 N68 N69 10000.0
R1708 N69 N70 10000.0
R1709 N70 N71 10000.0
R1710 N71 N72 10000.0
R1711 N72 N73 10000.0
R1712 N73 N74 10000.0
R1713 N74 N75 10000.0
R1714 N75 N76 10000.0
R1715 N76 N77 10000.0
R1716 N77 N78 10000.0
R1717 N78 N79 10000.0
R1718 N79 N80 10000.0
R1719 N81 N82 10000.0
R1720 N82 N83 10000.0
R1721 N83 N84 10000.0
R1722 N84 N85 10000.0
R1723 N85 N86 10000.0
R1724 N86 N87 10000.0
R1725 N87 N88 10000.0
R1726 N88 N89 10000.0
R1727 N89 N90 10000.0
R1728 N90 N91 10000.0
R1729 N91 N92 10000.0
R1730 N92 N93 10000.0
R1731 N93 N94 10000.0
R1732 N94 N95 10000.0
R1733 N95 N96 10000.0
R1734 N96 N97 10000.0
R1735 N97 N98 10000.0
R1736 N98 N99 10000.0
R1737 N99 N100 10000.0
R1738 N100 N101 10000.0
R1739 N101 N102 10000.0
R1740 N102 N103 5005.0
R1741 N103 N104 5005.0
R1742 N104 N105 10000.0
R1743 N105 N106 10000.0
R1744 N106 N107 10000.0
R1745 N107 N108 10000.0
R1746 N108 N109 10000.0
R1747 N109 N110 10000.0
R1748 N110 N111 10000.0
R1749 N111 N112 10000.0
R1750 N112 N113 10000.0
R1751 N113 N114 10000.0
R1752 N114 N115 10000.0
R1753 N115 N116 10000.0
R1754 N116 N117 10000.0
R1755 N117 N118 10000.0
R1756 N118 N119 10000.0
R1757 N119 N120 10000.0
R1758 N121 N122 10000.0
R1759 N122 N123 10000.0
R1760 N123 N124 10000.0
R1761 N124 N125 10000.0
R1762 N125 N126 10000.0
R1763 N126 N127 10000.0
R1764 N127 N128 10000.0
R1765 N128 N129 10000.0
R1766 N129 N130 10000.0
R1767 N130 N131 10000.0
R1768 N131 N132 10000.0
R1769 N132 N133 10000.0
R1770 N133 N134 10000.0
R1771 N134 N135 10000.0
R1772 N135 N136 10000.0
R1773 N136 N137 10000.0
R1774 N137 N138 10000.0
R1775 N138 N139 10000.0
R1776 N139 N140 10000.0
R1777 N140 N141 10000.0
R1778 N141 N142 10000.0
R1779 N142 N143 5005.0
R1780 N143 N144 5005.0
R1781 N144 N145 10000.0
R1782 N145 N146 10000.0
R1783 N146 N147 10000.0
R1784 N147 N148 10000.0
R1785 N148 N149 10000.0
R1786 N149 N150 10000.0
R1787 N150 N151 10000.0
R1788 N151 N152 10000.0
R1789 N152 N153 10000.0
R1790 N153 N154 10000.0
R1791 N154 N155 10000.0
R1792 N155 N156 10000.0
R1793 N156 N157 10000.0
R1794 N157 N158 10000.0
R1795 N158 N159 10000.0
R1796 N159 N160 10000.0
R1797 N161 N162 10000.0
R1798 N162 N163 10000.0
R1799 N163 N164 10000.0
R1800 N164 N165 10000.0
R1801 N165 N166 10000.0
R1802 N166 N167 10000.0
R1803 N167 N168 10000.0
R1804 N168 N169 10000.0
R1805 N169 N170 10000.0
R1806 N170 N171 10000.0
R1807 N171 N172 10000.0
R1808 N172 N173 10000.0
R1809 N173 N174 10000.0
R1810 N174 N175 10000.0
R1811 N175 N176 10000.0
R1812 N176 N177 10000.0
R1813 N177 N178 10000.0
R1814 N178 N179 10000.0
R1815 N179 N180 10000.0
R1816 N180 N181 10000.0
R1817 N181 N182 5005.0
R1818 N182 N183 10.0
R1819 N183 N184 5005.0
R1820 N184 N185 10000.0
R1821 N185 N186 10000.0
R1822 N186 N187 10000.0
R1823 N187 N188 10000.0
R1824 N188 N189 10000.0
R1825 N189 N190 10000.0
R1826 N190 N191 10000.0
R1827 N191 N192 10000.0
R1828 N192 N193 10000.0
R1829 N193 N194 10000.0
R1830 N194 N195 10000.0
R1831 N195 N196 10000.0
R1832 N196 N197 10000.0
R1833 N197 N198 10000.0
R1834 N198 N199 10000.0
R1835 N199 N200 10000.0
R1836 N201 N202 10000.0
R1837 N202 N203 10000.0
R1838 N203 N204 10000.0
R1839 N204 N205 10000.0
R1840 N205 N206 10000.0
R1841 N206 N207 10000.0
R1842 N207 N208 10000.0
R1843 N208 N209 10000.0
R1844 N209 N210 10000.0
R1845 N210 N211 10000.0
R1846 N211 N212 10000.0
R1847 N212 N213 10000.0
R1848 N213 N214 10000.0
R1849 N214 N215 10000.0
R1850 N215 N216 10000.0
R1851 N216 N217 10000.0
R1852 N217 N218 10000.0
R1853 N218 N219 5005.0
R1854 N219 N220 10.0
R1855 N220 N221 10.0
R1856 N221 N222 5005.0
R1857 N222 N223 5005.0
R1858 N223 N224 10.0
R1859 N224 N225 5005.0
R1860 N225 N226 10000.0
R1861 N226 N227 10000.0
R1862 N227 N228 10000.0
R1863 N228 N229 10000.0
R1864 N229 N230 10000.0
R1865 N230 N231 10000.0
R1866 N231 N232 10000.0
R1867 N232 N233 10000.0
R1868 N233 N234 10000.0
R1869 N234 N235 10000.0
R1870 N235 N236 10000.0
R1871 N236 N237 10000.0
R1872 N237 N238 10000.0
R1873 N238 N239 10000.0
R1874 N239 N240 10000.0
R1875 N241 N242 10000.0
R1876 N242 N243 10000.0
R1877 N243 N244 10000.0
R1878 N244 N245 10000.0
R1879 N245 N246 10000.0
R1880 N246 N247 10000.0
R1881 N247 N248 10000.0
R1882 N248 N249 10000.0
R1883 N249 N250 10000.0
R1884 N250 N251 10000.0
R1885 N251 N252 10000.0
R1886 N252 N253 10000.0
R1887 N253 N254 10000.0
R1888 N254 N255 10000.0
R1889 N255 N256 10000.0
R1890 N256 N257 10000.0
R1891 N257 N258 10000.0
R1892 N258 N259 10000.0
R1893 N259 N260 5005.0
R1894 N260 N261 10.0
R1895 N261 N262 10.0
R1896 N262 N263 10.0
R1897 N263 N264 5005.0
R1898 N264 N265 10000.0
R1899 N265 N266 10000.0
R1900 N266 N267 10000.0
R1901 N267 N268 10000.0
R1902 N268 N269 10000.0
R1903 N269 N270 10000.0
R1904 N270 N271 10000.0
R1905 N271 N272 10000.0
R1906 N272 N273 10000.0
R1907 N273 N274 10000.0
R1908 N274 N275 10000.0
R1909 N275 N276 10000.0
R1910 N276 N277 10000.0
R1911 N277 N278 10000.0
R1912 N278 N279 10000.0
R1913 N279 N280 10000.0
R1914 N281 N282 10000.0
R1915 N282 N283 10000.0
R1916 N283 N284 10000.0
R1917 N284 N285 10000.0
R1918 N285 N286 10000.0
R1919 N286 N287 10000.0
R1920 N287 N288 10000.0
R1921 N288 N289 10000.0
R1922 N289 N290 10000.0
R1923 N290 N291 10000.0
R1924 N291 N292 10000.0
R1925 N292 N293 10000.0
R1926 N293 N294 10000.0
R1927 N294 N295 10000.0
R1928 N295 N296 10000.0
R1929 N296 N297 10000.0
R1930 N297 N298 10000.0
R1931 N298 N299 10000.0
R1932 N299 N300 5005.0
R1933 N300 N301 10.0
R1934 N301 N302 10.0
R1935 N302 N303 5005.0
R1936 N303 N304 10000.0
R1937 N304 N305 10000.0
R1938 N305 N306 10000.0
R1939 N306 N307 10000.0
R1940 N307 N308 10000.0
R1941 N308 N309 10000.0
R1942 N309 N310 10000.0
R1943 N310 N311 10000.0
R1944 N311 N312 10000.0
R1945 N312 N313 10000.0
R1946 N313 N314 10000.0
R1947 N314 N315 10000.0
R1948 N315 N316 10000.0
R1949 N316 N317 10000.0
R1950 N317 N318 10000.0
R1951 N318 N319 10000.0
R1952 N319 N320 10000.0
R1953 N321 N322 10000.0
R1954 N322 N323 10000.0
R1955 N323 N324 10000.0
R1956 N324 N325 10000.0
R1957 N325 N326 10000.0
R1958 N326 N327 10000.0
R1959 N327 N328 10000.0
R1960 N328 N329 10000.0
R1961 N329 N330 10000.0
R1962 N330 N331 10000.0
R1963 N331 N332 10000.0
R1964 N332 N333 10000.0
R1965 N333 N334 10000.0
R1966 N334 N335 10000.0
R1967 N335 N336 10000.0
R1968 N336 N337 10000.0
R1969 N337 N338 10000.0
R1970 N338 N339 5005.0
R1971 N339 N340 5005.0
R1972 N340 N341 10000.0
R1973 N341 N342 5005.0
R1974 N342 N343 10.0
R1975 N343 N344 5005.0
R1976 N344 N345 10000.0
R1977 N345 N346 10000.0
R1978 N346 N347 10000.0
R1979 N347 N348 10000.0
R1980 N348 N349 10000.0
R1981 N349 N350 10000.0
R1982 N350 N351 10000.0
R1983 N351 N352 10000.0
R1984 N352 N353 10000.0
R1985 N353 N354 10000.0
R1986 N354 N355 10000.0
R1987 N355 N356 10000.0
R1988 N356 N357 10000.0
R1989 N357 N358 10000.0
R1990 N358 N359 10000.0
R1991 N359 N360 10000.0
R1992 N361 N362 10000.0
R1993 N362 N363 10000.0
R1994 N363 N364 10000.0
R1995 N364 N365 10000.0
R1996 N365 N366 10000.0
R1997 N366 N367 10000.0
R1998 N367 N368 10000.0
R1999 N368 N369 10000.0
R2000 N369 N370 10000.0
R2001 N370 N371 10000.0
R2002 N371 N372 10000.0
R2003 N372 N373 10000.0
R2004 N373 N374 10000.0
R2005 N374 N375 10000.0
R2006 N375 N376 10000.0
R2007 N376 N377 10000.0
R2008 N377 N378 10000.0
R2009 N378 N379 5005.0
R2010 N379 N380 5005.0
R2011 N380 N381 10000.0
R2012 N381 N382 5005.0
R2013 N382 N383 10.0
R2014 N383 N384 5005.0
R2015 N384 N385 10000.0
R2016 N385 N386 10000.0
R2017 N386 N387 10000.0
R2018 N387 N388 10000.0
R2019 N388 N389 10000.0
R2020 N389 N390 10000.0
R2021 N390 N391 10000.0
R2022 N391 N392 10000.0
R2023 N392 N393 10000.0
R2024 N393 N394 10000.0
R2025 N394 N395 10000.0
R2026 N395 N396 10000.0
R2027 N396 N397 10000.0
R2028 N397 N398 10000.0
R2029 N398 N399 10000.0
R2030 N399 N400 10000.0
R2031 N401 N402 10000.0
R2032 N402 N403 10000.0
R2033 N403 N404 10000.0
R2034 N404 N405 10000.0
R2035 N405 N406 10000.0
R2036 N406 N407 10000.0
R2037 N407 N408 10000.0
R2038 N408 N409 10000.0
R2039 N409 N410 10000.0
R2040 N410 N411 10000.0
R2041 N411 N412 10000.0
R2042 N412 N413 10000.0
R2043 N413 N414 10000.0
R2044 N414 N415 10000.0
R2045 N415 N416 10000.0
R2046 N416 N417 10000.0
R2047 N417 N418 10000.0
R2048 N418 N419 5005.0
R2049 N419 N420 10.0
R2050 N420 N421 5005.0
R2051 N421 N422 5005.0
R2052 N422 N423 10.0
R2053 N423 N424 10.0
R2054 N424 N425 5005.0
R2055 N425 N426 10000.0
R2056 N426 N427 10000.0
R2057 N427 N428 10000.0
R2058 N428 N429 10000.0
R2059 N429 N430 10000.0
R2060 N430 N431 10000.0
R2061 N431 N432 10000.0
R2062 N432 N433 10000.0
R2063 N433 N434 10000.0
R2064 N434 N435 10000.0
R2065 N435 N436 10000.0
R2066 N436 N437 10000.0
R2067 N437 N438 10000.0
R2068 N438 N439 10000.0
R2069 N439 N440 10000.0
R2070 N441 N442 10000.0
R2071 N442 N443 10000.0
R2072 N443 N444 10000.0
R2073 N444 N445 10000.0
R2074 N445 N446 10000.0
R2075 N446 N447 10000.0
R2076 N447 N448 10000.0
R2077 N448 N449 10000.0
R2078 N449 N450 10000.0
R2079 N450 N451 10000.0
R2080 N451 N452 10000.0
R2081 N452 N453 10000.0
R2082 N453 N454 10000.0
R2083 N454 N455 10000.0
R2084 N455 N456 10000.0
R2085 N456 N457 10000.0
R2086 N457 N458 10000.0
R2087 N458 N459 10000.0
R2088 N459 N460 5005.0
R2089 N460 N461 10.0
R2090 N461 N462 5005.0
R2091 N462 N463 5005.0
R2092 N463 N464 5005.0
R2093 N464 N465 10000.0
R2094 N465 N466 10000.0
R2095 N466 N467 10000.0
R2096 N467 N468 10000.0
R2097 N468 N469 10000.0
R2098 N469 N470 10000.0
R2099 N470 N471 10000.0
R2100 N471 N472 10000.0
R2101 N472 N473 10000.0
R2102 N473 N474 10000.0
R2103 N474 N475 10000.0
R2104 N475 N476 10000.0
R2105 N476 N477 10000.0
R2106 N477 N478 10000.0
R2107 N478 N479 10000.0
R2108 N479 N480 10000.0
R2109 N481 N482 10000.0
R2110 N482 N483 10000.0
R2111 N483 N484 10000.0
R2112 N484 N485 10000.0
R2113 N485 N486 10000.0
R2114 N486 N487 10000.0
R2115 N487 N488 10000.0
R2116 N488 N489 10000.0
R2117 N489 N490 10000.0
R2118 N490 N491 10000.0
R2119 N491 N492 10000.0
R2120 N492 N493 10000.0
R2121 N493 N494 10000.0
R2122 N494 N495 10000.0
R2123 N495 N496 10000.0
R2124 N496 N497 10000.0
R2125 N497 N498 10000.0
R2126 N498 N499 10000.0
R2127 N499 N500 5005.0
R2128 N500 N501 10.0
R2129 N501 N502 10.0
R2130 N502 N503 10.0
R2131 N503 N504 5005.0
R2132 N504 N505 10000.0
R2133 N505 N506 10000.0
R2134 N506 N507 10000.0
R2135 N507 N508 10000.0
R2136 N508 N509 10000.0
R2137 N509 N510 10000.0
R2138 N510 N511 10000.0
R2139 N511 N512 10000.0
R2140 N512 N513 10000.0
R2141 N513 N514 10000.0
R2142 N514 N515 10000.0
R2143 N515 N516 10000.0
R2144 N516 N517 10000.0
R2145 N517 N518 10000.0
R2146 N518 N519 10000.0
R2147 N519 N520 10000.0
R2148 N521 N522 10000.0
R2149 N522 N523 10000.0
R2150 N523 N524 10000.0
R2151 N524 N525 10000.0
R2152 N525 N526 10000.0
R2153 N526 N527 10000.0
R2154 N527 N528 10000.0
R2155 N528 N529 10000.0
R2156 N529 N530 10000.0
R2157 N530 N531 10000.0
R2158 N531 N532 10000.0
R2159 N532 N533 10000.0
R2160 N533 N534 10000.0
R2161 N534 N535 10000.0
R2162 N535 N536 10000.0
R2163 N536 N537 10000.0
R2164 N537 N538 10000.0
R2165 N538 N539 10000.0
R2166 N539 N540 10000.0
R2167 N540 N541 5005.0
R2168 N541 N542 10.0
R2169 N542 N543 5005.0
R2170 N543 N544 10000.0
R2171 N544 N545 10000.0
R2172 N545 N546 10000.0
R2173 N546 N547 10000.0
R2174 N547 N548 10000.0
R2175 N548 N549 10000.0
R2176 N549 N550 10000.0
R2177 N550 N551 10000.0
R2178 N551 N552 10000.0
R2179 N552 N553 10000.0
R2180 N553 N554 10000.0
R2181 N554 N555 10000.0
R2182 N555 N556 10000.0
R2183 N556 N557 10000.0
R2184 N557 N558 10000.0
R2185 N558 N559 10000.0
R2186 N559 N560 10000.0
R2187 N561 N562 10000.0
R2188 N562 N563 10000.0
R2189 N563 N564 10000.0
R2190 N564 N565 10000.0
R2191 N565 N566 10000.0
R2192 N566 N567 10000.0
R2193 N567 N568 10000.0
R2194 N568 N569 10000.0
R2195 N569 N570 10000.0
R2196 N570 N571 10000.0
R2197 N571 N572 10000.0
R2198 N572 N573 10000.0
R2199 N573 N574 10000.0
R2200 N574 N575 10000.0
R2201 N575 N576 10000.0
R2202 N576 N577 10000.0
R2203 N577 N578 10000.0
R2204 N578 N579 10000.0
R2205 N579 N580 10000.0
R2206 N580 N581 5005.0
R2207 N581 N582 10.0
R2208 N582 N583 5005.0
R2209 N583 N584 10000.0
R2210 N584 N585 10000.0
R2211 N585 N586 10000.0
R2212 N586 N587 10000.0
R2213 N587 N588 10000.0
R2214 N588 N589 10000.0
R2215 N589 N590 10000.0
R2216 N590 N591 10000.0
R2217 N591 N592 10000.0
R2218 N592 N593 10000.0
R2219 N593 N594 10000.0
R2220 N594 N595 10000.0
R2221 N595 N596 10000.0
R2222 N596 N597 10000.0
R2223 N597 N598 10000.0
R2224 N598 N599 10000.0
R2225 N599 N600 10000.0
R2226 N601 N602 10000.0
R2227 N602 N603 10000.0
R2228 N603 N604 10000.0
R2229 N604 N605 10000.0
R2230 N605 N606 10000.0
R2231 N606 N607 10000.0
R2232 N607 N608 10000.0
R2233 N608 N609 10000.0
R2234 N609 N610 10000.0
R2235 N610 N611 10000.0
R2236 N611 N612 10000.0
R2237 N612 N613 10000.0
R2238 N613 N614 10000.0
R2239 N614 N615 10000.0
R2240 N615 N616 10000.0
R2241 N616 N617 10000.0
R2242 N617 N618 10000.0
R2243 N618 N619 5005.0
R2244 N619 N620 5005.0
R2245 N620 N621 5005.0
R2246 N621 N622 10.0
R2247 N622 N623 5005.0
R2248 N623 N624 10000.0
R2249 N624 N625 10000.0
R2250 N625 N626 10000.0
R2251 N626 N627 10000.0
R2252 N627 N628 10000.0
R2253 N628 N629 10000.0
R2254 N629 N630 10000.0
R2255 N630 N631 10000.0
R2256 N631 N632 10000.0
R2257 N632 N633 10000.0
R2258 N633 N634 10000.0
R2259 N634 N635 10000.0
R2260 N635 N636 10000.0
R2261 N636 N637 10000.0
R2262 N637 N638 10000.0
R2263 N638 N639 10000.0
R2264 N639 N640 10000.0
R2265 N641 N642 10000.0
R2266 N642 N643 10000.0
R2267 N643 N644 10000.0
R2268 N644 N645 10000.0
R2269 N645 N646 10000.0
R2270 N646 N647 10000.0
R2271 N647 N648 10000.0
R2272 N648 N649 10000.0
R2273 N649 N650 10000.0
R2274 N650 N651 10000.0
R2275 N651 N652 10000.0
R2276 N652 N653 10000.0
R2277 N653 N654 10000.0
R2278 N654 N655 10000.0
R2279 N655 N656 10000.0
R2280 N656 N657 10000.0
R2281 N657 N658 10000.0
R2282 N658 N659 5005.0
R2283 N659 N660 10.0
R2284 N660 N661 10.0
R2285 N661 N662 5005.0
R2286 N662 N663 10000.0
R2287 N663 N664 10000.0
R2288 N664 N665 10000.0
R2289 N665 N666 10000.0
R2290 N666 N667 10000.0
R2291 N667 N668 10000.0
R2292 N668 N669 10000.0
R2293 N669 N670 10000.0
R2294 N670 N671 10000.0
R2295 N671 N672 10000.0
R2296 N672 N673 10000.0
R2297 N673 N674 10000.0
R2298 N674 N675 10000.0
R2299 N675 N676 10000.0
R2300 N676 N677 10000.0
R2301 N677 N678 10000.0
R2302 N678 N679 10000.0
R2303 N679 N680 10000.0
R2304 N681 N682 10000.0
R2305 N682 N683 10000.0
R2306 N683 N684 10000.0
R2307 N684 N685 10000.0
R2308 N685 N686 10000.0
R2309 N686 N687 10000.0
R2310 N687 N688 10000.0
R2311 N688 N689 10000.0
R2312 N689 N690 10000.0
R2313 N690 N691 10000.0
R2314 N691 N692 10000.0
R2315 N692 N693 10000.0
R2316 N693 N694 10000.0
R2317 N694 N695 10000.0
R2318 N695 N696 10000.0
R2319 N696 N697 10000.0
R2320 N697 N698 10000.0
R2321 N698 N699 10000.0
R2322 N699 N700 5005.0
R2323 N700 N701 10.0
R2324 N701 N702 10.0
R2325 N702 N703 5005.0
R2326 N703 N704 10000.0
R2327 N704 N705 10000.0
R2328 N705 N706 10000.0
R2329 N706 N707 10000.0
R2330 N707 N708 10000.0
R2331 N708 N709 10000.0
R2332 N709 N710 10000.0
R2333 N710 N711 10000.0
R2334 N711 N712 10000.0
R2335 N712 N713 10000.0
R2336 N713 N714 10000.0
R2337 N714 N715 10000.0
R2338 N715 N716 10000.0
R2339 N716 N717 10000.0
R2340 N717 N718 10000.0
R2341 N718 N719 10000.0
R2342 N719 N720 10000.0
R2343 N721 N722 10000.0
R2344 N722 N723 10000.0
R2345 N723 N724 10000.0
R2346 N724 N725 10000.0
R2347 N725 N726 10000.0
R2348 N726 N727 10000.0
R2349 N727 N728 10000.0
R2350 N728 N729 10000.0
R2351 N729 N730 10000.0
R2352 N730 N731 10000.0
R2353 N731 N732 10000.0
R2354 N732 N733 10000.0
R2355 N733 N734 10000.0
R2356 N734 N735 10000.0
R2357 N735 N736 10000.0
R2358 N736 N737 10000.0
R2359 N737 N738 10000.0
R2360 N738 N739 10000.0
R2361 N739 N740 5005.0
R2362 N740 N741 5005.0
R2363 N741 N742 5005.0
R2364 N742 N743 5005.0
R2365 N743 N744 10000.0
R2366 N744 N745 10000.0
R2367 N745 N746 10000.0
R2368 N746 N747 10000.0
R2369 N747 N748 10000.0
R2370 N748 N749 10000.0
R2371 N749 N750 10000.0
R2372 N750 N751 10000.0
R2373 N751 N752 10000.0
R2374 N752 N753 10000.0
R2375 N753 N754 10000.0
R2376 N754 N755 10000.0
R2377 N755 N756 10000.0
R2378 N756 N757 10000.0
R2379 N757 N758 10000.0
R2380 N758 N759 10000.0
R2381 N759 N760 10000.0
R2382 N761 N762 10000.0
R2383 N762 N763 10000.0
R2384 N763 N764 10000.0
R2385 N764 N765 10000.0
R2386 N765 N766 10000.0
R2387 N766 N767 10000.0
R2388 N767 N768 10000.0
R2389 N768 N769 10000.0
R2390 N769 N770 10000.0
R2391 N770 N771 10000.0
R2392 N771 N772 10000.0
R2393 N772 N773 10000.0
R2394 N773 N774 10000.0
R2395 N774 N775 10000.0
R2396 N775 N776 10000.0
R2397 N776 N777 10000.0
R2398 N777 N778 10000.0
R2399 N778 N779 5005.0
R2400 N779 N780 10.0
R2401 N780 N781 5005.0
R2402 N781 N782 5005.0
R2403 N782 N783 10.0
R2404 N783 N784 5005.0
R2405 N784 N785 10000.0
R2406 N785 N786 10000.0
R2407 N786 N787 10000.0
R2408 N787 N788 10000.0
R2409 N788 N789 10000.0
R2410 N789 N790 10000.0
R2411 N790 N791 10000.0
R2412 N791 N792 10000.0
R2413 N792 N793 10000.0
R2414 N793 N794 10000.0
R2415 N794 N795 10000.0
R2416 N795 N796 10000.0
R2417 N796 N797 10000.0
R2418 N797 N798 10000.0
R2419 N798 N799 10000.0
R2420 N799 N800 10000.0
R2421 N801 N802 10000.0
R2422 N802 N803 10000.0
R2423 N803 N804 10000.0
R2424 N804 N805 10000.0
R2425 N805 N806 10000.0
R2426 N806 N807 10000.0
R2427 N807 N808 10000.0
R2428 N808 N809 10000.0
R2429 N809 N810 10000.0
R2430 N810 N811 10000.0
R2431 N811 N812 10000.0
R2432 N812 N813 10000.0
R2433 N813 N814 10000.0
R2434 N814 N815 10000.0
R2435 N815 N816 10000.0
R2436 N816 N817 10000.0
R2437 N817 N818 10000.0
R2438 N818 N819 5005.0
R2439 N819 N820 10.0
R2440 N820 N821 5005.0
R2441 N821 N822 10000.0
R2442 N822 N823 5005.0
R2443 N823 N824 5005.0
R2444 N824 N825 10000.0
R2445 N825 N826 10000.0
R2446 N826 N827 10000.0
R2447 N827 N828 10000.0
R2448 N828 N829 10000.0
R2449 N829 N830 10000.0
R2450 N830 N831 10000.0
R2451 N831 N832 10000.0
R2452 N832 N833 10000.0
R2453 N833 N834 10000.0
R2454 N834 N835 10000.0
R2455 N835 N836 10000.0
R2456 N836 N837 10000.0
R2457 N837 N838 10000.0
R2458 N838 N839 10000.0
R2459 N839 N840 10000.0
R2460 N841 N842 10000.0
R2461 N842 N843 10000.0
R2462 N843 N844 10000.0
R2463 N844 N845 10000.0
R2464 N845 N846 10000.0
R2465 N846 N847 10000.0
R2466 N847 N848 10000.0
R2467 N848 N849 10000.0
R2468 N849 N850 10000.0
R2469 N850 N851 10000.0
R2470 N851 N852 10000.0
R2471 N852 N853 10000.0
R2472 N853 N854 10000.0
R2473 N854 N855 10000.0
R2474 N855 N856 10000.0
R2475 N856 N857 10000.0
R2476 N857 N858 5005.0
R2477 N858 N859 10.0
R2478 N859 N860 5005.0
R2479 N860 N861 10000.0
R2480 N861 N862 5005.0
R2481 N862 N863 10.0
R2482 N863 N864 5005.0
R2483 N864 N865 10000.0
R2484 N865 N866 10000.0
R2485 N866 N867 10000.0
R2486 N867 N868 10000.0
R2487 N868 N869 10000.0
R2488 N869 N870 10000.0
R2489 N870 N871 10000.0
R2490 N871 N872 10000.0
R2491 N872 N873 10000.0
R2492 N873 N874 10000.0
R2493 N874 N875 10000.0
R2494 N875 N876 10000.0
R2495 N876 N877 10000.0
R2496 N877 N878 10000.0
R2497 N878 N879 10000.0
R2498 N879 N880 10000.0
R2499 N881 N882 10000.0
R2500 N882 N883 10000.0
R2501 N883 N884 10000.0
R2502 N884 N885 10000.0
R2503 N885 N886 10000.0
R2504 N886 N887 10000.0
R2505 N887 N888 10000.0
R2506 N888 N889 10000.0
R2507 N889 N890 10000.0
R2508 N890 N891 10000.0
R2509 N891 N892 10000.0
R2510 N892 N893 10000.0
R2511 N893 N894 10000.0
R2512 N894 N895 10000.0
R2513 N895 N896 10000.0
R2514 N896 N897 10000.0
R2515 N897 N898 10000.0
R2516 N898 N899 5005.0
R2517 N899 N900 5005.0
R2518 N900 N901 10000.0
R2519 N901 N902 5005.0
R2520 N902 N903 10.0
R2521 N903 N904 5005.0
R2522 N904 N905 10000.0
R2523 N905 N906 10000.0
R2524 N906 N907 10000.0
R2525 N907 N908 10000.0
R2526 N908 N909 10000.0
R2527 N909 N910 10000.0
R2528 N910 N911 10000.0
R2529 N911 N912 10000.0
R2530 N912 N913 10000.0
R2531 N913 N914 10000.0
R2532 N914 N915 10000.0
R2533 N915 N916 10000.0
R2534 N916 N917 10000.0
R2535 N917 N918 10000.0
R2536 N918 N919 10000.0
R2537 N919 N920 10000.0
R2538 N921 N922 10000.0
R2539 N922 N923 10000.0
R2540 N923 N924 10000.0
R2541 N924 N925 10000.0
R2542 N925 N926 10000.0
R2543 N926 N927 10000.0
R2544 N927 N928 10000.0
R2545 N928 N929 10000.0
R2546 N929 N930 10000.0
R2547 N930 N931 10000.0
R2548 N931 N932 10000.0
R2549 N932 N933 10000.0
R2550 N933 N934 10000.0
R2551 N934 N935 10000.0
R2552 N935 N936 10000.0
R2553 N936 N937 5005.0
R2554 N937 N938 10.0
R2555 N938 N939 10.0
R2556 N939 N940 5005.0
R2557 N940 N941 10000.0
R2558 N941 N942 10000.0
R2559 N942 N943 5005.0
R2560 N943 N944 5005.0
R2561 N944 N945 10000.0
R2562 N945 N946 10000.0
R2563 N946 N947 10000.0
R2564 N947 N948 10000.0
R2565 N948 N949 10000.0
R2566 N949 N950 10000.0
R2567 N950 N951 10000.0
R2568 N951 N952 10000.0
R2569 N952 N953 10000.0
R2570 N953 N954 10000.0
R2571 N954 N955 10000.0
R2572 N955 N956 10000.0
R2573 N956 N957 10000.0
R2574 N957 N958 10000.0
R2575 N958 N959 10000.0
R2576 N959 N960 10000.0
R2577 N961 N962 10000.0
R2578 N962 N963 10000.0
R2579 N963 N964 10000.0
R2580 N964 N965 10000.0
R2581 N965 N966 10000.0
R2582 N966 N967 10000.0
R2583 N967 N968 10000.0
R2584 N968 N969 10000.0
R2585 N969 N970 10000.0
R2586 N970 N971 10000.0
R2587 N971 N972 10000.0
R2588 N972 N973 10000.0
R2589 N973 N974 10000.0
R2590 N974 N975 10000.0
R2591 N975 N976 10000.0
R2592 N976 N977 10000.0
R2593 N977 N978 10000.0
R2594 N978 N979 5005.0
R2595 N979 N980 5005.0
R2596 N980 N981 5005.0
R2597 N981 N982 10.0
R2598 N982 N983 10.0
R2599 N983 N984 5005.0
R2600 N984 N985 10000.0
R2601 N985 N986 10000.0
R2602 N986 N987 10000.0
R2603 N987 N988 10000.0
R2604 N988 N989 10000.0
R2605 N989 N990 10000.0
R2606 N990 N991 10000.0
R2607 N991 N992 10000.0
R2608 N992 N993 10000.0
R2609 N993 N994 10000.0
R2610 N994 N995 10000.0
R2611 N995 N996 10000.0
R2612 N996 N997 10000.0
R2613 N997 N998 10000.0
R2614 N998 N999 10000.0
R2615 N999 N1000 10000.0
R2616 N1001 N1002 10000.0
R2617 N1002 N1003 10000.0
R2618 N1003 N1004 10000.0
R2619 N1004 N1005 10000.0
R2620 N1005 N1006 10000.0
R2621 N1006 N1007 10000.0
R2622 N1007 N1008 10000.0
R2623 N1008 N1009 10000.0
R2624 N1009 N1010 10000.0
R2625 N1010 N1011 10000.0
R2626 N1011 N1012 10000.0
R2627 N1012 N1013 10000.0
R2628 N1013 N1014 10000.0
R2629 N1014 N1015 10000.0
R2630 N1015 N1016 10000.0
R2631 N1016 N1017 10000.0
R2632 N1017 N1018 10000.0
R2633 N1018 N1019 5005.0
R2634 N1019 N1020 10.0
R2635 N1020 N1021 10.0
R2636 N1021 N1022 10.0
R2637 N1022 N1023 5005.0
R2638 N1023 N1024 10000.0
R2639 N1024 N1025 10000.0
R2640 N1025 N1026 10000.0
R2641 N1026 N1027 10000.0
R2642 N1027 N1028 10000.0
R2643 N1028 N1029 10000.0
R2644 N1029 N1030 10000.0
R2645 N1030 N1031 10000.0
R2646 N1031 N1032 10000.0
R2647 N1032 N1033 10000.0
R2648 N1033 N1034 10000.0
R2649 N1034 N1035 10000.0
R2650 N1035 N1036 10000.0
R2651 N1036 N1037 10000.0
R2652 N1037 N1038 10000.0
R2653 N1038 N1039 10000.0
R2654 N1039 N1040 10000.0
R2655 N1041 N1042 10000.0
R2656 N1042 N1043 10000.0
R2657 N1043 N1044 10000.0
R2658 N1044 N1045 10000.0
R2659 N1045 N1046 10000.0
R2660 N1046 N1047 10000.0
R2661 N1047 N1048 10000.0
R2662 N1048 N1049 10000.0
R2663 N1049 N1050 10000.0
R2664 N1050 N1051 10000.0
R2665 N1051 N1052 10000.0
R2666 N1052 N1053 10000.0
R2667 N1053 N1054 10000.0
R2668 N1054 N1055 10000.0
R2669 N1055 N1056 10000.0
R2670 N1056 N1057 10000.0
R2671 N1057 N1058 5005.0
R2672 N1058 N1059 10.0
R2673 N1059 N1060 5005.0
R2674 N1060 N1061 5005.0
R2675 N1061 N1062 10.0
R2676 N1062 N1063 5005.0
R2677 N1063 N1064 10000.0
R2678 N1064 N1065 10000.0
R2679 N1065 N1066 10000.0
R2680 N1066 N1067 10000.0
R2681 N1067 N1068 10000.0
R2682 N1068 N1069 10000.0
R2683 N1069 N1070 10000.0
R2684 N1070 N1071 10000.0
R2685 N1071 N1072 10000.0
R2686 N1072 N1073 10000.0
R2687 N1073 N1074 10000.0
R2688 N1074 N1075 10000.0
R2689 N1075 N1076 10000.0
R2690 N1076 N1077 10000.0
R2691 N1077 N1078 10000.0
R2692 N1078 N1079 10000.0
R2693 N1079 N1080 10000.0
R2694 N1081 N1082 10000.0
R2695 N1082 N1083 10000.0
R2696 N1083 N1084 10000.0
R2697 N1084 N1085 10000.0
R2698 N1085 N1086 10000.0
R2699 N1086 N1087 10000.0
R2700 N1087 N1088 10000.0
R2701 N1088 N1089 10000.0
R2702 N1089 N1090 10000.0
R2703 N1090 N1091 10000.0
R2704 N1091 N1092 10000.0
R2705 N1092 N1093 10000.0
R2706 N1093 N1094 10000.0
R2707 N1094 N1095 10000.0
R2708 N1095 N1096 10000.0
R2709 N1096 N1097 10000.0
R2710 N1097 N1098 10000.0
R2711 N1098 N1099 5005.0
R2712 N1099 N1100 10.0
R2713 N1100 N1101 10.0
R2714 N1101 N1102 10.0
R2715 N1102 N1103 5005.0
R2716 N1103 N1104 10000.0
R2717 N1104 N1105 10000.0
R2718 N1105 N1106 10000.0
R2719 N1106 N1107 10000.0
R2720 N1107 N1108 10000.0
R2721 N1108 N1109 10000.0
R2722 N1109 N1110 10000.0
R2723 N1110 N1111 10000.0
R2724 N1111 N1112 10000.0
R2725 N1112 N1113 10000.0
R2726 N1113 N1114 10000.0
R2727 N1114 N1115 10000.0
R2728 N1115 N1116 10000.0
R2729 N1116 N1117 10000.0
R2730 N1117 N1118 10000.0
R2731 N1118 N1119 10000.0
R2732 N1119 N1120 10000.0
R2733 N1121 N1122 10000.0
R2734 N1122 N1123 10000.0
R2735 N1123 N1124 10000.0
R2736 N1124 N1125 10000.0
R2737 N1125 N1126 10000.0
R2738 N1126 N1127 10000.0
R2739 N1127 N1128 10000.0
R2740 N1128 N1129 10000.0
R2741 N1129 N1130 10000.0
R2742 N1130 N1131 10000.0
R2743 N1131 N1132 10000.0
R2744 N1132 N1133 10000.0
R2745 N1133 N1134 10000.0
R2746 N1134 N1135 10000.0
R2747 N1135 N1136 10000.0
R2748 N1136 N1137 10000.0
R2749 N1137 N1138 10000.0
R2750 N1138 N1139 5005.0
R2751 N1139 N1140 5005.0
R2752 N1140 N1141 5005.0
R2753 N1141 N1142 5005.0
R2754 N1142 N1143 10000.0
R2755 N1143 N1144 10000.0
R2756 N1144 N1145 10000.0
R2757 N1145 N1146 10000.0
R2758 N1146 N1147 10000.0
R2759 N1147 N1148 10000.0
R2760 N1148 N1149 10000.0
R2761 N1149 N1150 10000.0
R2762 N1150 N1151 10000.0
R2763 N1151 N1152 10000.0
R2764 N1152 N1153 10000.0
R2765 N1153 N1154 10000.0
R2766 N1154 N1155 10000.0
R2767 N1155 N1156 10000.0
R2768 N1156 N1157 10000.0
R2769 N1157 N1158 10000.0
R2770 N1158 N1159 10000.0
R2771 N1159 N1160 10000.0
R2772 N1161 N1162 10000.0
R2773 N1162 N1163 10000.0
R2774 N1163 N1164 10000.0
R2775 N1164 N1165 10000.0
R2776 N1165 N1166 10000.0
R2777 N1166 N1167 10000.0
R2778 N1167 N1168 10000.0
R2779 N1168 N1169 10000.0
R2780 N1169 N1170 10000.0
R2781 N1170 N1171 10000.0
R2782 N1171 N1172 10000.0
R2783 N1172 N1173 10000.0
R2784 N1173 N1174 10000.0
R2785 N1174 N1175 10000.0
R2786 N1175 N1176 10000.0
R2787 N1176 N1177 10000.0
R2788 N1177 N1178 5005.0
R2789 N1178 N1179 10.0
R2790 N1179 N1180 5005.0
R2791 N1180 N1181 5005.0
R2792 N1181 N1182 5005.0
R2793 N1182 N1183 10000.0
R2794 N1183 N1184 10000.0
R2795 N1184 N1185 10000.0
R2796 N1185 N1186 10000.0
R2797 N1186 N1187 10000.0
R2798 N1187 N1188 10000.0
R2799 N1188 N1189 10000.0
R2800 N1189 N1190 10000.0
R2801 N1190 N1191 10000.0
R2802 N1191 N1192 10000.0
R2803 N1192 N1193 10000.0
R2804 N1193 N1194 10000.0
R2805 N1194 N1195 10000.0
R2806 N1195 N1196 10000.0
R2807 N1196 N1197 10000.0
R2808 N1197 N1198 10000.0
R2809 N1198 N1199 10000.0
R2810 N1199 N1200 10000.0
R2811 N1201 N1202 10000.0
R2812 N1202 N1203 10000.0
R2813 N1203 N1204 10000.0
R2814 N1204 N1205 10000.0
R2815 N1205 N1206 10000.0
R2816 N1206 N1207 10000.0
R2817 N1207 N1208 10000.0
R2818 N1208 N1209 10000.0
R2819 N1209 N1210 10000.0
R2820 N1210 N1211 10000.0
R2821 N1211 N1212 10000.0
R2822 N1212 N1213 10000.0
R2823 N1213 N1214 10000.0
R2824 N1214 N1215 10000.0
R2825 N1215 N1216 10000.0
R2826 N1216 N1217 10000.0
R2827 N1217 N1218 10000.0
R2828 N1218 N1219 5005.0
R2829 N1219 N1220 5005.0
R2830 N1220 N1221 5005.0
R2831 N1221 N1222 5005.0
R2832 N1222 N1223 10000.0
R2833 N1223 N1224 5005.0
R2834 N1224 N1225 10.0
R2835 N1225 N1226 5005.0
R2836 N1226 N1227 10000.0
R2837 N1227 N1228 10000.0
R2838 N1228 N1229 10000.0
R2839 N1229 N1230 10000.0
R2840 N1230 N1231 10000.0
R2841 N1231 N1232 10000.0
R2842 N1232 N1233 10000.0
R2843 N1233 N1234 10000.0
R2844 N1234 N1235 10000.0
R2845 N1235 N1236 10000.0
R2846 N1236 N1237 10000.0
R2847 N1237 N1238 10000.0
R2848 N1238 N1239 10000.0
R2849 N1239 N1240 10000.0
R2850 N1241 N1242 10000.0
R2851 N1242 N1243 10000.0
R2852 N1243 N1244 10000.0
R2853 N1244 N1245 10000.0
R2854 N1245 N1246 10000.0
R2855 N1246 N1247 10000.0
R2856 N1247 N1248 10000.0
R2857 N1248 N1249 10000.0
R2858 N1249 N1250 10000.0
R2859 N1250 N1251 10000.0
R2860 N1251 N1252 10000.0
R2861 N1252 N1253 10000.0
R2862 N1253 N1254 5005.0
R2863 N1254 N1255 10.0
R2864 N1255 N1256 10.0
R2865 N1256 N1257 10.0
R2866 N1257 N1258 10.0
R2867 N1258 N1259 10.0
R2868 N1259 N1260 10.0
R2869 N1260 N1261 10.0
R2870 N1261 N1262 10.0
R2871 N1262 N1263 10.0
R2872 N1263 N1264 10.0
R2873 N1264 N1265 10.0
R2874 N1265 N1266 5005.0
R2875 N1266 N1267 10000.0
R2876 N1267 N1268 10000.0
R2877 N1268 N1269 10000.0
R2878 N1269 N1270 10000.0
R2879 N1270 N1271 10000.0
R2880 N1271 N1272 10000.0
R2881 N1272 N1273 10000.0
R2882 N1273 N1274 10000.0
R2883 N1274 N1275 10000.0
R2884 N1275 N1276 10000.0
R2885 N1276 N1277 10000.0
R2886 N1277 N1278 10000.0
R2887 N1278 N1279 10000.0
R2888 N1279 N1280 10000.0
R2889 N1281 N1282 10000.0
R2890 N1282 N1283 10000.0
R2891 N1283 N1284 10000.0
R2892 N1284 N1285 10000.0
R2893 N1285 N1286 10000.0
R2894 N1286 N1287 10000.0
R2895 N1287 N1288 10000.0
R2896 N1288 N1289 10000.0
R2897 N1289 N1290 10000.0
R2898 N1290 N1291 10000.0
R2899 N1291 N1292 10000.0
R2900 N1292 N1293 10000.0
R2901 N1293 N1294 5005.0
R2902 N1294 N1295 10.0
R2903 N1295 N1296 5005.0
R2904 N1296 N1297 10000.0
R2905 N1297 N1298 5005.0
R2906 N1298 N1299 5005.0
R2907 N1299 N1300 5005.0
R2908 N1300 N1301 10.0
R2909 N1301 N1302 5005.0
R2910 N1302 N1303 10000.0
R2911 N1303 N1304 5005.0
R2912 N1304 N1305 10.0
R2913 N1305 N1306 5005.0
R2914 N1306 N1307 10000.0
R2915 N1307 N1308 10000.0
R2916 N1308 N1309 10000.0
R2917 N1309 N1310 10000.0
R2918 N1310 N1311 10000.0
R2919 N1311 N1312 10000.0
R2920 N1312 N1313 10000.0
R2921 N1313 N1314 10000.0
R2922 N1314 N1315 10000.0
R2923 N1315 N1316 10000.0
R2924 N1316 N1317 10000.0
R2925 N1317 N1318 10000.0
R2926 N1318 N1319 10000.0
R2927 N1319 N1320 10000.0
R2928 N1321 N1322 10000.0
R2929 N1322 N1323 10000.0
R2930 N1323 N1324 10000.0
R2931 N1324 N1325 10000.0
R2932 N1325 N1326 10000.0
R2933 N1326 N1327 10000.0
R2934 N1327 N1328 10000.0
R2935 N1328 N1329 10000.0
R2936 N1329 N1330 10000.0
R2937 N1330 N1331 10000.0
R2938 N1331 N1332 10000.0
R2939 N1332 N1333 10000.0
R2940 N1333 N1334 10000.0
R2941 N1334 N1335 5005.0
R2942 N1335 N1336 10.0
R2943 N1336 N1337 10.0
R2944 N1337 N1338 10.0
R2945 N1338 N1339 5005.0
R2946 N1339 N1340 5005.0
R2947 N1340 N1341 10.0
R2948 N1341 N1342 5005.0
R2949 N1342 N1343 10000.0
R2950 N1343 N1344 10000.0
R2951 N1344 N1345 5005.0
R2952 N1345 N1346 5005.0
R2953 N1346 N1347 10000.0
R2954 N1347 N1348 10000.0
R2955 N1348 N1349 10000.0
R2956 N1349 N1350 10000.0
R2957 N1350 N1351 10000.0
R2958 N1351 N1352 10000.0
R2959 N1352 N1353 10000.0
R2960 N1353 N1354 10000.0
R2961 N1354 N1355 10000.0
R2962 N1355 N1356 10000.0
R2963 N1356 N1357 10000.0
R2964 N1357 N1358 10000.0
R2965 N1358 N1359 10000.0
R2966 N1359 N1360 10000.0
R2967 N1361 N1362 10000.0
R2968 N1362 N1363 10000.0
R2969 N1363 N1364 10000.0
R2970 N1364 N1365 10000.0
R2971 N1365 N1366 10000.0
R2972 N1366 N1367 10000.0
R2973 N1367 N1368 10000.0
R2974 N1368 N1369 10000.0
R2975 N1369 N1370 10000.0
R2976 N1370 N1371 10000.0
R2977 N1371 N1372 10000.0
R2978 N1372 N1373 10000.0
R2979 N1373 N1374 10000.0
R2980 N1374 N1375 10000.0
R2981 N1375 N1376 5005.0
R2982 N1376 N1377 10.0
R2983 N1377 N1378 10.0
R2984 N1378 N1379 10.0
R2985 N1379 N1380 10.0
R2986 N1380 N1381 5005.0
R2987 N1381 N1382 10000.0
R2988 N1382 N1383 10000.0
R2989 N1383 N1384 10000.0
R2990 N1384 N1385 5005.0
R2991 N1385 N1386 5005.0
R2992 N1386 N1387 10000.0
R2993 N1387 N1388 10000.0
R2994 N1388 N1389 10000.0
R2995 N1389 N1390 10000.0
R2996 N1390 N1391 10000.0
R2997 N1391 N1392 10000.0
R2998 N1392 N1393 10000.0
R2999 N1393 N1394 10000.0
R3000 N1394 N1395 10000.0
R3001 N1395 N1396 10000.0
R3002 N1396 N1397 10000.0
R3003 N1397 N1398 10000.0
R3004 N1398 N1399 10000.0
R3005 N1399 N1400 10000.0
R3006 N1401 N1402 10000.0
R3007 N1402 N1403 10000.0
R3008 N1403 N1404 10000.0
R3009 N1404 N1405 10000.0
R3010 N1405 N1406 10000.0
R3011 N1406 N1407 10000.0
R3012 N1407 N1408 10000.0
R3013 N1408 N1409 10000.0
R3014 N1409 N1410 10000.0
R3015 N1410 N1411 10000.0
R3016 N1411 N1412 10000.0
R3017 N1412 N1413 10000.0
R3018 N1413 N1414 10000.0
R3019 N1414 N1415 10000.0
R3020 N1415 N1416 10000.0
R3021 N1416 N1417 10000.0
R3022 N1417 N1418 5005.0
R3023 N1418 N1419 10.0
R3024 N1419 N1420 5005.0
R3025 N1420 N1421 10000.0
R3026 N1421 N1422 10000.0
R3027 N1422 N1423 10000.0
R3028 N1423 N1424 10000.0
R3029 N1424 N1425 5005.0
R3030 N1425 N1426 5005.0
R3031 N1426 N1427 5005.0
R3032 N1427 N1428 5005.0
R3033 N1428 N1429 10000.0
R3034 N1429 N1430 10000.0
R3035 N1430 N1431 10000.0
R3036 N1431 N1432 10000.0
R3037 N1432 N1433 10000.0
R3038 N1433 N1434 10000.0
R3039 N1434 N1435 10000.0
R3040 N1435 N1436 10000.0
R3041 N1436 N1437 10000.0
R3042 N1437 N1438 10000.0
R3043 N1438 N1439 10000.0
R3044 N1439 N1440 10000.0
R3045 N1441 N1442 10000.0
R3046 N1442 N1443 10000.0
R3047 N1443 N1444 10000.0
R3048 N1444 N1445 10000.0
R3049 N1445 N1446 10000.0
R3050 N1446 N1447 10000.0
R3051 N1447 N1448 10000.0
R3052 N1448 N1449 10000.0
R3053 N1449 N1450 10000.0
R3054 N1450 N1451 10000.0
R3055 N1451 N1452 5005.0
R3056 N1452 N1453 5005.0
R3057 N1453 N1454 10000.0
R3058 N1454 N1455 10000.0
R3059 N1455 N1456 10000.0
R3060 N1456 N1457 10000.0
R3061 N1457 N1458 5005.0
R3062 N1458 N1459 10.0
R3063 N1459 N1460 5005.0
R3064 N1460 N1461 10000.0
R3065 N1461 N1462 10000.0
R3066 N1462 N1463 10000.0
R3067 N1463 N1464 10000.0
R3068 N1464 N1465 5005.0
R3069 N1465 N1466 5005.0
R3070 N1466 N1467 5005.0
R3071 N1467 N1468 10.0
R3072 N1468 N1469 5005.0
R3073 N1469 N1470 10000.0
R3074 N1470 N1471 10000.0
R3075 N1471 N1472 10000.0
R3076 N1472 N1473 10000.0
R3077 N1473 N1474 10000.0
R3078 N1474 N1475 10000.0
R3079 N1475 N1476 10000.0
R3080 N1476 N1477 10000.0
R3081 N1477 N1478 10000.0
R3082 N1478 N1479 10000.0
R3083 N1479 N1480 10000.0
R3084 N1481 N1482 10000.0
R3085 N1482 N1483 10000.0
R3086 N1483 N1484 10000.0
R3087 N1484 N1485 10000.0
R3088 N1485 N1486 10000.0
R3089 N1486 N1487 10000.0
R3090 N1487 N1488 10000.0
R3091 N1488 N1489 10000.0
R3092 N1489 N1490 10000.0
R3093 N1490 N1491 10000.0
R3094 N1491 N1492 5005.0
R3095 N1492 N1493 10.0
R3096 N1493 N1494 5005.0
R3097 N1494 N1495 10000.0
R3098 N1495 N1496 10000.0
R3099 N1496 N1497 10000.0
R3100 N1497 N1498 5005.0
R3101 N1498 N1499 5005.0
R3102 N1499 N1500 10000.0
R3103 N1500 N1501 10000.0
R3104 N1501 N1502 10000.0
R3105 N1502 N1503 10000.0
R3106 N1503 N1504 5005.0
R3107 N1504 N1505 10.0
R3108 N1505 N1506 5005.0
R3109 N1506 N1507 10000.0
R3110 N1507 N1508 5005.0
R3111 N1508 N1509 5005.0
R3112 N1509 N1510 10000.0
R3113 N1510 N1511 10000.0
R3114 N1511 N1512 10000.0
R3115 N1512 N1513 10000.0
R3116 N1513 N1514 10000.0
R3117 N1514 N1515 10000.0
R3118 N1515 N1516 10000.0
R3119 N1516 N1517 10000.0
R3120 N1517 N1518 10000.0
R3121 N1518 N1519 10000.0
R3122 N1519 N1520 10000.0
R3123 N1521 N1522 10000.0
R3124 N1522 N1523 10000.0
R3125 N1523 N1524 10000.0
R3126 N1524 N1525 10000.0
R3127 N1525 N1526 10000.0
R3128 N1526 N1527 10000.0
R3129 N1527 N1528 10000.0
R3130 N1528 N1529 10000.0
R3131 N1529 N1530 10000.0
R3132 N1530 N1531 10000.0
R3133 N1531 N1532 10000.0
R3134 N1532 N1533 5005.0
R3135 N1533 N1534 5005.0
R3136 N1534 N1535 10000.0
R3137 N1535 N1536 10000.0
R3138 N1536 N1537 10000.0
R3139 N1537 N1538 5005.0
R3140 N1538 N1539 5005.0
R3141 N1539 N1540 10000.0
R3142 N1540 N1541 10000.0
R3143 N1541 N1542 10000.0
R3144 N1542 N1543 10000.0
R3145 N1543 N1544 5005.0
R3146 N1544 N1545 10.0
R3147 N1545 N1546 10.0
R3148 N1546 N1547 10.0
R3149 N1547 N1548 10.0
R3150 N1548 N1549 10.0
R3151 N1549 N1550 5005.0
R3152 N1550 N1551 10000.0
R3153 N1551 N1552 10000.0
R3154 N1552 N1553 10000.0
R3155 N1553 N1554 10000.0
R3156 N1554 N1555 10000.0
R3157 N1555 N1556 10000.0
R3158 N1556 N1557 10000.0
R3159 N1557 N1558 10000.0
R3160 N1558 N1559 10000.0
R3161 N1559 N1560 10000.0
R3162 N1561 N1562 10000.0
R3163 N1562 N1563 10000.0
R3164 N1563 N1564 10000.0
R3165 N1564 N1565 10000.0
R3166 N1565 N1566 10000.0
R3167 N1566 N1567 10000.0
R3168 N1567 N1568 10000.0
R3169 N1568 N1569 10000.0
R3170 N1569 N1570 10000.0
R3171 N1570 N1571 10000.0
R3172 N1571 N1572 5005.0
R3173 N1572 N1573 10.0
R3174 N1573 N1574 10.0
R3175 N1574 N1575 5005.0
R3176 N1575 N1576 10000.0
R3177 N1576 N1577 10000.0
R3178 N1577 N1578 5005.0
R3179 N1578 N1579 5005.0
R3180 N1579 N1580 5005.0
R3181 N1580 N1581 10.0
R3182 N1581 N1582 5005.0
R3183 N1582 N1583 10000.0
R3184 N1583 N1584 5005.0
R3185 N1584 N1585 10.0
R3186 N1585 N1586 10.0
R3187 N1586 N1587 5005.0
R3188 N1587 N1588 10000.0
R3189 N1588 N1589 10000.0
R3190 N1589 N1590 10000.0
R3191 N1590 N1591 10000.0
R3192 N1591 N1592 5005.0
R3193 N1592 N1593 10.0
R3194 N1593 N1594 5005.0
R3195 N1594 N1595 10000.0
R3196 N1595 N1596 10000.0
R3197 N1596 N1597 10000.0
R3198 N1597 N1598 10000.0
R3199 N1598 N1599 10000.0
R3200 N1599 N1600 10000.0
R3201 N1601 N1602 10000.0
R3202 N1602 N1603 10000.0
R3203 N1603 N1604 10000.0
R3204 N1604 N1605 10000.0
R3205 N1605 N1606 10000.0
R3206 N1606 N1607 10000.0
R3207 N1607 N1608 10000.0
R3208 N1608 N1609 10000.0
R3209 N1609 N1610 10000.0
R3210 N1610 N1611 10000.0
R3211 N1611 N1612 10000.0
R3212 N1612 N1613 5005.0
R3213 N1613 N1614 5005.0
R3214 N1614 N1615 10000.0
R3215 N1615 N1616 10000.0
R3216 N1616 N1617 10000.0
R3217 N1617 N1618 5005.0
R3218 N1618 N1619 10.0
R3219 N1619 N1620 10.0
R3220 N1620 N1621 10.0
R3221 N1621 N1622 5005.0
R3222 N1622 N1623 10000.0
R3223 N1623 N1624 5005.0
R3224 N1624 N1625 5005.0
R3225 N1625 N1626 5005.0
R3226 N1626 N1627 5005.0
R3227 N1627 N1628 10000.0
R3228 N1628 N1629 10000.0
R3229 N1629 N1630 10000.0
R3230 N1630 N1631 10000.0
R3231 N1631 N1632 5005.0
R3232 N1632 N1633 10.0
R3233 N1633 N1634 5005.0
R3234 N1634 N1635 10000.0
R3235 N1635 N1636 10000.0
R3236 N1636 N1637 10000.0
R3237 N1637 N1638 10000.0
R3238 N1638 N1639 10000.0
R3239 N1639 N1640 10000.0
R3240 N1641 N1642 0.0001
R3241 N1642 N1643 0.0001
R3242 N1643 N1644 0.0001
R3243 N1644 N1645 0.0001
R3244 N1645 N1646 0.0001
R3245 N1646 N1647 0.0001
R3246 N1647 N1648 0.0001
R3247 N1648 N1649 0.0001
R3248 N1649 N1650 0.0001
R3249 N1650 N1651 0.0001
R3250 N1651 N1652 0.0001
R3251 N1652 N1653 0.0001
R3252 N1653 N1654 0.0001
R3253 N1654 N1655 0.0001
R3254 N1655 N1656 0.0001
R3255 N1656 N1657 0.0001
R3256 N1657 N1658 0.0001
R3257 N1658 N1659 0.0001
R3258 N1659 N1660 0.0001
R3259 N1660 N1661 0.0001
R3260 N1661 N1662 0.0001
R3261 N1662 N1663 0.0001
R3262 N1663 N1664 0.0001
R3263 N1664 N1665 0.0001
R3264 N1665 N1666 0.0001
R3265 N1666 N1667 0.0001
R3266 N1667 N1668 0.0001
R3267 N1668 N1669 0.0001
R3268 N1669 N1670 0.0001
R3269 N1670 N1671 0.0001
R3270 N1671 N1672 0.0001
R3271 N1672 N1673 0.0001
R3272 N1673 N1674 0.0001
R3273 N1674 N1675 0.0001
R3274 N1675 N1676 0.0001
R3275 N1676 N1677 0.0001
R3276 N1677 N1678 0.0001
R3277 N1678 N1679 0.0001
R3278 N1679 0 0.0001
I1 N1 0 1
.op
.savebias spiceout.txt
